Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [Ikke spesifisert]
File name: m_f-elektro_jording-i-bru.ifc (Edited by Naviate Simple BIM 10.1 version 2)
Time: 2026-03-23T19:42:46
Author: André Fygle
Organization: Trimble Solutions Sandvika AS
Written by: Ifc Engine <1.0.1.1367>
Made in: Trimble Inc. - Novapoint - 27.0.1266.0
Authorization: André Fygle

# IfcProject, Default Project
Description: Description Of Project

# IfcSite
ePset_ModelInfo - ModelName: m_f-elektro_jording-i-bru.ifc; Timestamp: 2026-03-23T19:42:46

# IfcBuilding
ePset_ModelInfo - ModelName: m_f-elektro_jording-i-bru.ifc; Timestamp: 2026-03-23T19:42:46

# IfcBuildingStorey
ePset_ModelInfo - ModelName: m_f-elektro_jording-i-bru.ifc; Timestamp: 2026-03-23T19:42:46

# IfcFlowSegment (14)
ePset_ModelInfo - ModelName: m_f-elektro_jording-i-bru.ifc; Timestamp: 2026-03-23T19:42:46
Merknader - M53 Eier: Statens vegvesen; M51 Type: IX; M50 Objektnavn: Jordingsleder; M52 Dimensjon: 25mm2
Tittelfelt - T03 Dato: 24.03.2026; T10 Kontrollert av: renlie; T09 Utarbeidet av: andfyg; T05 Produsert for: DoV midt; T00 Prosjektnavn: E6 Ny Lundamo bru; T01 Vegstrekning: EV6 K S70D1 m9800 - S71D1 m340; T02 Prosjektfase: Konkurransegrunnlag; T07 PROF-nummer: C16939-202; T04 Bestiller: Thorstein Johnsen; T06 Produsert av: Fagressurs DoV
Pset_Draughting - Red: 0; Green: 176; Blue: 80
Name | P04 Prosessnavn | P06 Enhet | P03 Prosessnummer | P05 Mengde
 | Utjevningsforbindelser rekkverk | stk | 87.6253 | 1.48508
 | Utjevningsforbindelser rekkverk | stk | 87.6253 | 4.39327
 | Utjevningsforbindelser armering | stk | 87.6252 | 2.02453
 | Utjevningsforbindelser fra gjennomgående jording til luke jordingspunkt | stk | 87.6255 | 7.05838
 | Utjevningsforbindelser armering | stk | 87.6252 | 1.8151
 | Utjevningsforbindelser fra gjennomgående jording til luke jordingspunkt | stk | 87.6255 | 6.02454
 | Utjevningsforbindelser rekkverk | stk | 87.6253 | 4.37907
 | Utjevningsforbindelser rekkverk | stk | 87.6253 | 3.94793
 | Utjevningsforbindelser rekkverk | stk | 87.6253 | 4.223
 | Utjevningsforbindelser rekkverk | stk | 87.6253 | 7.97721
 | Utjevningsforbindelser lysmast | stk | 87.6254 | 1.25397
 | Utjevningsforbindelser lysmast | stk | 87.6254 | 1.54297
 | Utjevningsforbindelser lysmast | stk | 87.6254 | 4.16903
 | Isolert leder 25 mm2 gul/grønn | m | 87.6233 | 155.077 | Prosessinfo - P02 Element: H1 Elektro Bru; P01 Sted: E1 Elektro
