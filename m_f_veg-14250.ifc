Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: ViewDefinition [Alignment-basedView]
File name: C:\Users\klaids\AppData\Local\Temp\Trimble\ConnectFolder\ m_f_veg-14250.ifc
Time: 2026-03-03T15:26:58
Author: Klaid Schjetne
Written by: Ifc Engine <1.0.1.1369>
Made in: Trimble Inc. - Novapoint - 28.0.290.0
Authorization: Klaid Schjetne

# IfcProject, Default Project
Description: Description of the Project

# IfcSite (2)
Name
Default Site | RefLatitude: 10, 17, 27; RefLongitude: 63, 9, 13; RefElevation: 32.7336 m
m_f_Veg-14250-Midlt-omkj

# IfcActor (2)
Name
 | Pset_Address - Purpose: OFFICE; Country: Norway


# IfcAnnotation (27)
In: m_f_Veg-14250-Midlt-omkj|ROADSEGMENT
PredefinedType: SURVEY
Name | Description
4 x m_f_Veg-14250-Midlt-omkj / 7.11 / H. Fylling 11 / Line | StakeOutStringTopLevel
3 x m_f_Veg-14250-Midlt-omkj / 6.10 / H.Jordskj 10 / Line | StakeOutStringTopLevel
3 x m_f_Veg-14250-Midlt-omkj / 4.01 / H. Grøft 1 / Line | StakeOutStringTopLevel
3 x m_f_Veg-14250-Midlt-omkj / -7.11 / V. Fylling 11 / Line | StakeOutStringTopLevel
m_f_Veg-14250-Midlt-omkj / -2.01 / V. Skulder 1 / Line | StakeOutStringTopLevel
m_f_Veg-14250-Midlt-omkj / 6.11 / H. Jordskj. 11 / Line | StakeOutStringTopLevel
m_f_Veg-14250-Midlt-omkj / -4.01 / V. Grøft 1 / Line | StakeOutStringTopLevel
m_f_Veg-14250-Midlt-omkj / -4.01 / V.Jordskj 10 / Line | StakeOutStringTopLevel
m_f_Veg-14250-Midlt-omkj / 0 / Pavement / Centre Line | StakeOutStringTopLevel
m_f_Veg-14250-Midlt-omkj / 2.02 / H.Rekkverk / Line | StakeOutStringTopLevel
m_f_Veg-14250-Midlt-omkj / 1.01 / H. Kjørefelt 1 / Line | StakeOutStringTopLevel
m_f_Veg-14250-Midlt-omkj / 2.01 / H. Skulder 1 / Line | StakeOutStringTopLevel
m_f_Veg-14250-Midlt-omkj / -1.01 / V. Kjørefelt 1 / Line | StakeOutStringTopLevel
m_f_Veg-14250-Midlt-omkj / -1.02 / V. breddeutvidelse / Line | StakeOutStringTopLevel
m_f_Veg-14250-Midlt-omkj / 1.02 / H. breddeutvidelse / Line | StakeOutStringTopLevel
m_f_Veg-14250-Midlt-omkj / -2.02 / V.Rekkverk / Line | StakeOutStringTopLevel
m_f_Veg-14250-Midlt-omkj / Planum / Outer Boundary | StakeOutStringSubgradeImprovement
m_f_Veg-14250-Midlt-omkj / -6.10 / V.Jordskj 10 / Line | StakeOutStringTopLevel

# IfcCourse (4)
In: m_f_Veg-14250-Midlt-omkj|ROADSEGMENT
PredefinedType: PAVEMENT; Material: Asphalt
Name
m_f_Veg-14250-Midlt-omkj / Bærelag 2
m_f_Veg-14250-Midlt-omkj / Bindlag 1
m_f_Veg-14250-Midlt-omkj / Slitelag
m_f_Veg-14250-Midlt-omkj / Bærelag 1

# IfcCourse: ROADSHOULDER_SURFACE (4)
In: m_f_Veg-14250-Midlt-omkj|SHOULDER
PredefinedType: USERDEFINED
Name
m_f_Veg-14250-Midlt-omkj / -2.02 / V.Rekkverk
m_f_Veg-14250-Midlt-omkj / -2.01 / V. Skulder 1
m_f_Veg-14250-Midlt-omkj / 2.01 / H. Skulder 1
m_f_Veg-14250-Midlt-omkj / 2.02 / H.Rekkverk

# IfcCourse: TRAFFICLANE_SURFACE (6)
In: m_f_Veg-14250-Midlt-omkj|CARRIAGEWAY
PredefinedType: USERDEFINED
Name
2 x m_f_Veg-14250-Midlt-omkj / 1.02 / H. breddeutvidelse
2 x m_f_Veg-14250-Midlt-omkj / -1.02 / V. breddeutvidelse
m_f_Veg-14250-Midlt-omkj / -1.01 / V. Kjørefelt 1
m_f_Veg-14250-Midlt-omkj / 1.01 / H. Kjørefelt 1

# IfcDistributionChamberElement (4)
In: m_f_Veg-14250-Midlt-omkj|ROADSIDE
PredefinedType: TRENCH
Name
3 x m_f_Veg-14250-Midlt-omkj / 4.01 / H. Grøft 1
m_f_Veg-14250-Midlt-omkj / -4.01 / V. Grøft 1

# IfcEarthworksCut (3)
In: m_f_Veg-14250-Midlt-omkj
PredefinedType: CUT

# IfcEarthworksCut: LOWESTCONSTRUCTIONWORKSURFACE (4)
In: m_f_Veg-14250-Midlt-omkj
PredefinedType: USERDEFINED

# IfcEarthworksFill (37)
Name | In | PredefinedType
7 x m_f_Veg-14250-Midlt-omkj / SubgradeSurface Outside Pavement | m_f_Veg-14250-Midlt-omkj/ROADSEGMENT | SUBGRADEBED
4 x m_f_Veg-14250-Midlt-omkj / 7.11 / H. Fylling 11 | m_f_Veg-14250-Midlt-omkj/ROADSIDE | SLOPEFILL
5 x m_f_Veg-14250-Midlt-omkj / SubgradeSurface Inside Pavement / OnFill | m_f_Veg-14250-Midlt-omkj/ROADSEGMENT | SUBGRADEBED
3 x m_f_Veg-14250-Midlt-omkj / 6.10 / H.Jordskj 10 | m_f_Veg-14250-Midlt-omkj/ROADSIDE | SLOPEFILL
3 x m_f_Veg-14250-Midlt-omkj / -7.11 / V. Fylling 11 | m_f_Veg-14250-Midlt-omkj/ROADSIDE | SLOPEFILL
2 x m_f_Veg-14250-Midlt-omkj / 6.11 / H. Jordskj. 11 | m_f_Veg-14250-Midlt-omkj/ROADSIDE | SLOPEFILL
3 x m_f_Veg-14250-Midlt-omkj / SubgradeSurface Inside Pavement / InCutSoil | m_f_Veg-14250-Midlt-omkj/ROADSEGMENT | SUBGRADEBED
4 x m_f_Veg-14250-Midlt-omkj / Filterlag | m_f_Veg-14250-Midlt-omkj/ROADSEGMENT | SUBGRADEBED | Material: Gravel
m_f_Veg-14250-Midlt-omkj / Forsterkningslag 1 | m_f_Veg-14250-Midlt-omkj/ROADSEGMENT | SUBGRADEBED | Material: Crushed stone
3 x m_f_Veg-14250-Midlt-omkj / Fyllingslag / Solid | m_f_Veg-14250-Midlt-omkj/ROADSEGMENT | EMBANKMENT | Material: Crushed stone
m_f_Veg-14250-Midlt-omkj / -6.10 / V.Jordskj 10 | m_f_Veg-14250-Midlt-omkj/ROADSIDE | SLOPEFILL
m_f_Veg-14250-Midlt-omkj/SUBGRADE | m_f_Veg-14250-Midlt-omkj/ROADSEGMENT | SUBGRADE

# IfcEarthworksFill: LOWESTCONSTRUCTIONWORKSURFACE (6)
In: m_f_Veg-14250-Midlt-omkj|ROADSEGMENT
PredefinedType: USERDEFINED

# IfcPavement, m_f_Veg-14250-Midlt-omkj|RIGID
In: m_f_Veg-14250-Midlt-omkj|ROADSEGMENT
PredefinedType: RIGID

# IfcRoad: Road, m_f_Veg-14250-Midlt-omkj
PredefinedType: USERDEFINED

# IfcRoadPart (4)
Name | UsageType | PredefinedType
m_f_Veg-14250-Midlt-omkj/ROADSEGMENT | LONGITUDINAL | ROADSEGMENT
m_f_Veg-14250-Midlt-omkj/CARRIAGEWAY | LATERAL | CARRIAGEWAY
m_f_Veg-14250-Midlt-omkj/SHOULDER | LATERAL | SHOULDER
m_f_Veg-14250-Midlt-omkj/ROADSIDE | LATERAL | ROADSIDE
