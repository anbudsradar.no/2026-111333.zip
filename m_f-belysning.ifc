Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverAddonView, ConceptDesignBIM_2010]
File name: m_f-belysning.ifc (Edited by Naviate Simple BIM 10.1 version 2)
Time: 2026-03-30T14:41:39
Author: ANDFYG
Written by: ODA SDAI 24.6
Made in: Build

# IfcProject, C16939
LongName: E6 Ny Lundamo bru

# IfcSite
ePset_ModelInfo - ModelName: m_f-belysning.ifc; Timestamp: 2026-03-30T14:41:39

# IfcBuilding
ePset_ModelInfo - ModelName: m_f-belysning.ifc; Timestamp: 2026-03-30T14:41:39

# IfcBuildingElementProxy (2)
ePset_ModelInfo - ModelName: m_f-belysning.ifc; Timestamp: 2026-03-30T14:41:39
Prosessinfo - P05 Mengde: 0
Merknader - M01 Armaturnummer: UP; M11 Mastenummer: KM
Pset_Draughting - Red: 0; Green: 0; Blue: 0

# IfcBuildingElementProxy: *U24
ePset_ModelInfo - ModelName: m_f-belysning.ifc; Timestamp: 2026-03-30T14:41:39
Prosessinfo - P08 Prosessnavn 2: Lysarmatur LED 10 m mast; P02 Element: D1 Elektro Vei; P10 Enhet 2: stk; P05 Mengde: 1; P03 Prosessnummer: 16.321; P09 Mengde 2: 1; P04 Prosessnavn: Demontering av master/stolper, fundamenter og armatur; P01 Sted: E1 Elektro; P07 Prosessnummer 2: 76.3631; P06 Enhet: RS
Merknader - M11 Mastenummer: KM001; M01 Armaturnummer: UP001; M61 Tegningshenvisning: IN001, IN051 og IN054; M12 Materiale mast: Stål; M10 Objektnavn mast: Veglysmast; M00 Objektnavn armatur: Veglysarmatur
Tittelfelt - T10 Kontrollert av: renlie; T09 Utarbeidet av: andfyg; T05 Produsert for: DoV midt; T01 Vegstrekning: Ev006 S70D1 m9800 - S71D1 m340; T04 Bestiller: Thorstein Kjøs Johnsen; T02 Prosjektfase: Konkurransegrunnlag; T07 PROF-nummer: C16939-202; T06 Produsert av: Fagressurs DoV; T03 Dato: 24.03.26; T00 Prosjektnavn: E6 Lundamo bru
Pset_Draughting - Red: 0; Green: 0; Blue: 0

# IfcBuildingElementProxy: *U39
ePset_ModelInfo - ModelName: m_f-belysning.ifc; Timestamp: 2026-03-30T14:41:39
Merknader - M31 Fordelingsnummer: =7432.001; M61 Tegningshenvisning: IN001, IN052, IN055 og N001; M36 Skapfarge: RAL 7042; M32 TFM-merking: +S50VLS73D1 =7432.001; M34 Eier: Statens vegvesen; M30 Objektnavn: Fordelingsskap; M33 Enlinjeskjema navn: N001
Prosessinfo - P02 Element: D1 Elektro Vei; P04 Prosessnavn: Hovedfordelinger; P06 Enhet: stk; P05 Mengde: 1; P03 Prosessnummer: 76.351; P01 Sted: E1 Elektro
Tittelfelt - T10 Kontrollert av: renlie; T09 Utarbeidet av: andfyg; T05 Produsert for: DoV midt; T01 Vegstrekning: Ev006 S70D1 m9800 - S71D1 m340; T04 Bestiller: Thorstein Kjøs Johnsen; T02 Prosjektfase: Konkurransegrunnlag; T07 PROF-nummer: C16939-202; T06 Produsert av: Fagressurs DoV; T03 Dato: 24.03.26; T00 Prosjektnavn: E6 Lundamo bru
Pset_Draughting - Red: 204; Green: 204; Blue: 204

# IfcBuildingElementProxy: *U44
ePset_ModelInfo - ModelName: m_f-belysning.ifc; Timestamp: 2026-03-30T14:41:39
Prosessinfo - P12 Prosessnavn 3: Lysarmatur LED 10 m mast; P02 Element: D1 Elektro Vei; P07 Prosessnummer 2: 76.34231; P03 Prosessnummer: 76.34631; P10 Enhet 2: stk; P14 Enhet 3: stk; P06 Enhet: stk; P08 Prosessnavn 2: HE-mast 10m; P05 Mengde: 1; P13 Mengde 3: 1; P09 Mengde 2: 1; P01 Sted: E1 Elektro; P11 Prosessnummer 3: 76.3631; P04 Prosessnavn: Stålfundament til HE mast 10m
Merknader - M06 Eier armatur: Statens vegvesen; M41 Eier fundament: Statens vegvesen; M61 Tegningshenvisning: IN001, IN051 og IN054; M15 Lyspunkthøyde mast: 10m; M11 Mastenummer: KM011; M12 Materiale mast: Stål; M42 Materiale fundament: Stål; M10 Objektnavn mast: Veglysmast; M14 Påkjøringssikring mast: HE; M43 Påkjøringssikring fundament: HE; M01 Armaturnummer: UP011; M40 Objektnavn fundament: Veglysmastfundament; M00 Objektnavn armatur: Veglysarmatur
Tittelfelt - T10 Kontrollert av: renlie; T09 Utarbeidet av: andfyg; T05 Produsert for: DoV midt; T01 Vegstrekning: Ev006 S70D1 m9800 - S71D1 m340; T04 Bestiller: Thorstein Kjøs Johnsen; T02 Prosjektfase: Konkurransegrunnlag; T07 PROF-nummer: C16939-202; T06 Produsert av: Fagressurs DoV; T03 Dato: 24.03.26; T00 Prosjektnavn: E6 Lundamo bru
Pset_Draughting - Red: 0; Green: 0; Blue: 0

# IfcBuildingElementProxy: *U45 (3)
ePset_ModelInfo - ModelName: m_f-belysning.ifc; Timestamp: 2026-03-30T14:41:39
Merknader - M06 Eier armatur: Statens vegvesen; M61 Tegningshenvisning: IN001, IN051 og IN054; M12 Materiale mast: Stål; M10 Objektnavn mast: Veglysmast; M00 Objektnavn armatur: Veglysarmatur
Prosessinfo - P12 Prosessnavn 3: Lysarmatur LED 10 m mast; P02 Element: D1 Elektro Vei; P07 Prosessnummer 2: 76.34231; P03 Prosessnummer: 76.34631; P10 Enhet 2: stk; P14 Enhet 3: stk; P06 Enhet: stk; P08 Prosessnavn 2: HE-mast 10m; P05 Mengde: 1; P13 Mengde 3: 1; P09 Mengde 2: 1; P01 Sted: E1 Elektro; P11 Prosessnummer 3: 76.3631; P04 Prosessnavn: Stålfundament til HE mast 10m
Tittelfelt - T10 Kontrollert av: renlie; T09 Utarbeidet av: andfyg; T05 Produsert for: DoV midt; T01 Vegstrekning: Ev006 S70D1 m9800 - S71D1 m340; T04 Bestiller: Thorstein Kjøs Johnsen; T02 Prosjektfase: Konkurransegrunnlag; T07 PROF-nummer: C16939-202; T06 Produsert av: Fagressurs DoV; T03 Dato: 24.03.26; T00 Prosjektnavn: E6 Lundamo bru
Pset_Draughting - Red: 0; Green: 0; Blue: 0
Name | M11 Mastenummer | M01 Armaturnummer
 | KM003 | UP003
 | KM002 | UP002
 | KM004 | UP004

# IfcBuildingElementProxy: *U46
ePset_ModelInfo - ModelName: m_f-belysning.ifc; Timestamp: 2026-03-30T14:41:39
Prosessinfo - P12 Prosessnavn 3: Lysarmatur LED 10 m mast; P02 Element: D1 Elektro Vei; P07 Prosessnummer 2: 76.34231; P03 Prosessnummer: 76.34631; P10 Enhet 2: stk; P14 Enhet 3: stk; P06 Enhet: stk; P08 Prosessnavn 2: HE-mast 10m; P05 Mengde: 1; P13 Mengde 3: 1; P09 Mengde 2: 1; P01 Sted: E1 Elektro; P11 Prosessnummer 3: 76.3631; P04 Prosessnavn: Stålfundament til HE mast 10m
Merknader - M11 Mastenummer: KM008; M01 Armaturnummer: UP008; M06 Eier armatur: Statens vegvesen; M41 Eier fundament: Statens vegvesen; M61 Tegningshenvisning: IN001, IN051 og IN054; M15 Lyspunkthøyde mast: 10m; M44 Lyspunkthøyde fundament: 10m; M12 Materiale mast: Stål; M42 Materiale fundament: Stål; M10 Objektnavn mast: Veglysmast; M14 Påkjøringssikring mast: HE; M43 Påkjøringssikring fundament: HE; M40 Objektnavn fundament: Veglysmastfundament; M00 Objektnavn armatur: Veglysarmatur
Tittelfelt - T10 Kontrollert av: renlie; T09 Utarbeidet av: andfyg; T05 Produsert for: DoV midt; T01 Vegstrekning: Ev006 S70D1 m9800 - S71D1 m340; T04 Bestiller: Thorstein Kjøs Johnsen; T02 Prosjektfase: Konkurransegrunnlag; T07 PROF-nummer: C16939-202; T06 Produsert av: Fagressurs DoV; T03 Dato: 24.03.26; T00 Prosjektnavn: E6 Lundamo bru
Pset_Draughting - Red: 0; Green: 0; Blue: 0

# IfcBuildingElementProxy: *U47
ePset_ModelInfo - ModelName: m_f-belysning.ifc; Timestamp: 2026-03-30T14:41:39
Prosessinfo - P12 Prosessnavn 3: Lysarmatur LED 10 m mast; P02 Element: D1 Elektro Vei; P07 Prosessnummer 2: 76.34231; P03 Prosessnummer: 76.34631; P10 Enhet 2: stk; P14 Enhet 3: stk; P06 Enhet: stk; P08 Prosessnavn 2: HE-mast 10m; P05 Mengde: 1; P13 Mengde 3: 1; P09 Mengde 2: 1; P01 Sted: E1 Elektro; P11 Prosessnummer 3: 76.3631; P04 Prosessnavn: Stålfundament til HE mast 10m
Merknader - M11 Mastenummer: KM009; M01 Armaturnummer: UP009; M06 Eier armatur: Statens vegvesen; M41 Eier fundament: Statens vegvesen; M61 Tegningshenvisning: IN001, IN051 og IN054; M15 Lyspunkthøyde mast: 10m; M44 Lyspunkthøyde fundament: 10m; M12 Materiale mast: Stål; M42 Materiale fundament: Stål; M10 Objektnavn mast: Veglysmast; M14 Påkjøringssikring mast: HE; M43 Påkjøringssikring fundament: HE; M40 Objektnavn fundament: Veglysmastfundament; M00 Objektnavn armatur: Veglysarmatur
Tittelfelt - T10 Kontrollert av: renlie; T09 Utarbeidet av: andfyg; T05 Produsert for: DoV midt; T01 Vegstrekning: Ev006 S70D1 m9800 - S71D1 m340; T04 Bestiller: Thorstein Kjøs Johnsen; T02 Prosjektfase: Konkurransegrunnlag; T07 PROF-nummer: C16939-202; T06 Produsert av: Fagressurs DoV; T03 Dato: 24.03.26; T00 Prosjektnavn: E6 Lundamo bru
Pset_Draughting - Red: 0; Green: 0; Blue: 0

# IfcBuildingElementProxy: *U48
ePset_ModelInfo - ModelName: m_f-belysning.ifc; Timestamp: 2026-03-30T14:41:39
Prosessinfo - P12 Prosessnavn 3: Lysarmatur LED 10 m mast; P02 Element: D1 Elektro Vei; P07 Prosessnummer 2: 76.34231; P03 Prosessnummer: 76.34631; P10 Enhet 2: stk; P14 Enhet 3: stk; P06 Enhet: stk; P08 Prosessnavn 2: HE-mast 10m; P05 Mengde: 1; P13 Mengde 3: 1; P09 Mengde 2: 1; P01 Sted: E1 Elektro; P11 Prosessnummer 3: 76.3631; P04 Prosessnavn: Stålfundament til HE mast 10m
Merknader - M06 Eier armatur: Statens vegvesen; M41 Eier fundament: Statens vegvesen; M61 Tegningshenvisning: IN001, IN051 og IN054; M15 Lyspunkthøyde mast: 10m; M44 Lyspunkthøyde fundament: 10m; M11 Mastenummer: KM010; M12 Materiale mast: Stål; M42 Materiale fundament: Stål; M10 Objektnavn mast: Veglysmast; M14 Påkjøringssikring mast: HE; M43 Påkjøringssikring fundament: HE; M01 Armaturnummer: UP010; M40 Objektnavn fundament: Veglysmastfundament; M00 Objektnavn armatur: Veglysarmatur
Tittelfelt - T10 Kontrollert av: renlie; T09 Utarbeidet av: andfyg; T05 Produsert for: DoV midt; T01 Vegstrekning: Ev006 S70D1 m9800 - S71D1 m340; T04 Bestiller: Thorstein Kjøs Johnsen; T02 Prosjektfase: Konkurransegrunnlag; T07 PROF-nummer: C16939-202; T06 Produsert av: Fagressurs DoV; T03 Dato: 24.03.26; T00 Prosjektnavn: E6 Lundamo bru
Pset_Draughting - Red: 0; Green: 0; Blue: 0

# IfcBuildingElementProxy: *U49 (2)
ePset_ModelInfo - ModelName: m_f-belysning.ifc; Timestamp: 2026-03-30T14:41:39
Merknader - M06 Eier armatur: Statens vegvesen; M61 Tegningshenvisning: IN001, IN051 og IN054; M12 Materiale mast: Stål; M10 Objektnavn mast: Veglysmast; M00 Objektnavn armatur: Veglysarmatur
Prosessinfo - P07 Prosessnummer 2: 76.34232; P02 Element: D1 Elektro Vei; P03 Prosessnummer: 76.34632; P08 Prosessnavn 2: HE-mast 8m; P10 Enhet 2: stk; P14 Enhet 3: stk; P06 Enhet: stk; P05 Mengde: 1; P13 Mengde 3: 1; P09 Mengde 2: 1; P12 Prosessnavn 3: Lysarmatur LED 8m mast G&S; P01 Sted: E1 Elektro; P11 Prosessnummer 3: 76.3633; P04 Prosessnavn: Stålfundament til HE mast 8m
Tittelfelt - T10 Kontrollert av: renlie; T09 Utarbeidet av: andfyg; T05 Produsert for: DoV midt; T01 Vegstrekning: Ev006 S70D1 m9800 - S71D1 m340; T04 Bestiller: Thorstein Kjøs Johnsen; T02 Prosjektfase: Konkurransegrunnlag; T07 PROF-nummer: C16939-202; T06 Produsert av: Fagressurs DoV; T03 Dato: 24.03.26; T00 Prosjektnavn: E6 Lundamo bru
Pset_Draughting - Red: 0; Green: 0; Blue: 0
Name | M11 Mastenummer | M01 Armaturnummer
 | KM202 | UP202
 | KM203 | UP203

# IfcBuildingElementProxy: *U50
ePset_ModelInfo - ModelName: m_f-belysning.ifc; Timestamp: 2026-03-30T14:41:39
Merknader - M11 Mastenummer: KM201; M01 Armaturnummer: UP201; M06 Eier armatur: Statens vegvesen; M61 Tegningshenvisning: IN001, IN051 og IN054; M12 Materiale mast: Stål; M10 Objektnavn mast: Veglysmast; M00 Objektnavn armatur: Veglysarmatur
Prosessinfo - P07 Prosessnummer 2: 76.34232; P02 Element: D1 Elektro Vei; P03 Prosessnummer: 76.34632; P08 Prosessnavn 2: HE-mast 8m; P10 Enhet 2: stk; P14 Enhet 3: stk; P06 Enhet: stk; P05 Mengde: 1; P13 Mengde 3: 1; P09 Mengde 2: 1; P12 Prosessnavn 3: Lysarmatur LED 8m mast G&S; P01 Sted: E1 Elektro; P11 Prosessnummer 3: 76.3633; P04 Prosessnavn: Stålfundament til HE mast 8m
Tittelfelt - T10 Kontrollert av: renlie; T09 Utarbeidet av: andfyg; T05 Produsert for: DoV midt; T01 Vegstrekning: Ev006 S70D1 m9800 - S71D1 m340; T04 Bestiller: Thorstein Kjøs Johnsen; T02 Prosjektfase: Konkurransegrunnlag; T07 PROF-nummer: C16939-202; T06 Produsert av: Fagressurs DoV; T03 Dato: 24.03.26; T00 Prosjektnavn: E6 Lundamo bru
Pset_Draughting - Red: 0; Green: 0; Blue: 0

# IfcBuildingElementProxy: *U51
ePset_ModelInfo - ModelName: m_f-belysning.ifc; Timestamp: 2026-03-30T14:41:39
Merknader - M11 Mastenummer: KM204; M01 Armaturnummer: UP204; M06 Eier armatur: Statens vegvesen; M61 Tegningshenvisning: IN001, IN051 og IN054; M12 Materiale mast: Stål; M10 Objektnavn mast: Veglysmast; M00 Objektnavn armatur: Veglysarmatur
Prosessinfo - P07 Prosessnummer 2: 76.34232; P02 Element: D1 Elektro Vei; P03 Prosessnummer: 76.34632; P08 Prosessnavn 2: HE-mast 8m; P10 Enhet 2: stk; P14 Enhet 3: stk; P06 Enhet: stk; P05 Mengde: 1; P13 Mengde 3: 1; P09 Mengde 2: 1; P12 Prosessnavn 3: Lysarmatur LED 8m mast G&S; P01 Sted: E1 Elektro; P11 Prosessnummer 3: 76.3633; P04 Prosessnavn: Stålfundament til HE mast 8m
Tittelfelt - T10 Kontrollert av: renlie; T09 Utarbeidet av: andfyg; T05 Produsert for: DoV midt; T01 Vegstrekning: Ev006 S70D1 m9800 - S71D1 m340; T04 Bestiller: Thorstein Kjøs Johnsen; T02 Prosjektfase: Konkurransegrunnlag; T07 PROF-nummer: C16939-202; T06 Produsert av: Fagressurs DoV; T03 Dato: 24.03.26; T00 Prosjektnavn: E6 Lundamo bru
Pset_Draughting - Red: 0; Green: 0; Blue: 0

# IfcBuildingElementProxy: *U52 (3)
ePset_ModelInfo - ModelName: m_f-belysning.ifc; Timestamp: 2026-03-30T14:41:39
Prosessinfo - P08 Prosessnavn 2: Lysarmatur LED 10 m mast; P02 Element: D1 Elektro Vei; P03 Prosessnummer: 76.34221; P10 Enhet 2: stk; P06 Enhet: stk; P04 Prosessnavn: NE-mast 10m; P05 Mengde: 1; P09 Mengde 2: 1; P01 Sted: E1 Elektro; P07 Prosessnummer 2: 76.3631
Merknader - M06 Eier armatur: Statens vegvesen; M61 Tegningshenvisning: IN001, IN051 og IN054; M15 Lyspunkthøyde mast: 10m; M12 Materiale mast: Stål; M10 Objektnavn mast: Veglysmast; M14 Påkjøringssikring mast: NE; M00 Objektnavn armatur: Veglysarmatur
Tittelfelt - T10 Kontrollert av: renlie; T09 Utarbeidet av: andfyg; T05 Produsert for: DoV midt; T01 Vegstrekning: Ev006 S70D1 m9800 - S71D1 m340; T04 Bestiller: Thorstein Kjøs Johnsen; T02 Prosjektfase: Konkurransegrunnlag; T07 PROF-nummer: C16939-202; T06 Produsert av: Fagressurs DoV; T03 Dato: 24.03.26; T00 Prosjektnavn: E6 Lundamo bru
Pset_Draughting - Red: 0; Green: 0; Blue: 0
Name | M11 Mastenummer | M01 Armaturnummer
 | KM007 | UP007
 | KM006 | UP006
 | KM005 | UP005

# IfcBuildingElementProxy: Mastekonsoll_cc240mm (3)
ePset_ModelInfo - ModelName: m_f-belysning.ifc; Timestamp: 2026-03-30T14:41:39
Merknader - M41 Eier fundament: Statens vegvesen; M42 Materiale fundament: Stål; M61 Tegningshenvisning: IN001; M40 Objektnavn fundament: Brakett; M43 Påkjøringssikring fundament: NE
Tittelfelt - T10 Kontrollert av: renlie; T09 Utarbeidet av: andfyg; T05 Produsert for: DoV midt; T01 Vegstrekning: Ev006 S70D1 m9800 - S71D1 m340; T04 Bestiller: Thorstein Kjøs Johnsen; T02 Prosjektfase: Konkurransegrunnlag; T07 PROF-nummer: C16939-202; T06 Produsert av: Fagressurs DoV; T03 Dato: 24.03.26; T00 Prosjektnavn: E6 Lundamo bru
Prosessinfo - P06 Enhet: stk; P04 Prosessnavn: Brakett for feste av master til vegbelysning; P05 Mengde: 1; P01 Sted: E1 Elektro; P03 Prosessnummer: 87.635
Pset_Draughting - Red: 0; Green: 0; Blue: 0
Name | M44 Lyspunkthøyde fundament | P02 Element
 | 12m | D1 Elektro Vei
 | 12m | H1 Elektro Bru
 | 10m | D1 Elektro Vei
