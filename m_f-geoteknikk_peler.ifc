Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: C:\Users\janaal\OneDrive - Statens vegvesen\Grasshopper\Lundamo\m_f-geoteknikk_peler.ifc
Time: 2026-04-30T11:33:24
Author: janaal
Organization: VEGVESEN
Written by: ggIFC v25.3.25.7 by Geometry Gym Pty Ltd built 2025-03-25T15:49:14
Made in: Geometry Gym - ggRhinoIFC - v25.3.25.7 - Rhino7 Grasshopper3d Plug-in by Geometry Gym Pty Ltd
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization

# IfcProject, E16 Lundamo bru
Description: Geofag; Phase: Prosjektering

# IfcSite, Fagmodell geoteknikk
RefElevation: 0 m

# IfcSite: IfcFacility, Betongpeler
Pset Tittelfelt - KA-001 Prosjektnavn: E6 Lundamo bru; KA-002 Brunummer: C16939; KA-003 Brunavn: C16939; KA-004 Prosjektfase: C16939; KA-005 Koordinatsystem: C16939; KA-006 Høydesystem: C16939; KA-012 Byggherre: C16939; KA-013 Byggherrerepresentant: C16939; KA-014 Modelldato: C16939; KA-015 Prosjekterende: C16939; KA-016 Utarbeidet av: C16939; KA-017 Kontrollert av: C16939; KA-018 Godkjent av: C16939; KA-020 Revisjonsdato: C16939; KA-021 Revidert av: C16939; KA-022 Kontrollert av: C16939; KA-023 Godkjent av: C16939; KA-024 Entreprenør: C16939; KA-025 Prosjektnummer: C16939; KA-026 Arkivreferanse: C16939

# IfcPile: FRICTION (40)
In: Betongpeler
PredefinedType: FRICTION; Material: Armert betong
Merknader - Objektnavn: Peler; Prosesskode: 83.1; MMI: 325
Name | Akse | Pelenummer
Betongpel | 2 | 1
Betongpel | 2 | 2
Betongpel | 2 | 3
Betongpel | 2 | 4
Betongpel | 2 | 5
Betongpel | 2 | 6
Betongpel | 2 | 7
Betongpel | 2 | 8
Betongpel | 2 | 9
Betongpel | 2 | 10
Betongpel | 2 | 11
Betongpel | 2 | 12
Betongpel | 2 | 13
Betongpel | 2 | 14
Betongpel | 2 | 15
Betongpel | 2 | 16
Betongpel | 2 | 17
Betongpel | 2 | 18
Betongpel | 2 | 19
Betongpel | 2 | 20
Betongpel | 1 | 1
Betongpel | 1 | 2
Betongpel | 1 | 3
Betongpel | 1 | 4
Betongpel | 1 | 5
Betongpel | 1 | 6
Betongpel | 1 | 7
Betongpel | 1 | 8
Betongpel | 1 | 9
Betongpel | 1 | 10
Betongpel | 1 | 11
Betongpel | 1 | 12
Betongpel | 1 | 13
Betongpel | 1 | 14
Betongpel | 1 | 15
Betongpel | 1 | 16
Betongpel | 1 | 17
Betongpel | 1 | 18
Betongpel | 1 | 19
Betongpel | 1 | 20
