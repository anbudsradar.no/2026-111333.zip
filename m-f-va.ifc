Properties of the parts of a building model (IFC4X3_ADD2), part 3 of 3

# IfcDistributionChamberElement (79)
Name | In | TYPEID | VIPSSURFACENO | VIPSSURFACENAME | ShortestHorizontalLength (m) | LongestHorizontalLength (m) | ProjectedAreaInTheHorizontalPlane (m2)
Trase8 / 6.01 / Utility Trench Edge Surface | Trase8/ROADSIDE | Utility Trench Edge Surface | 6.01 | Trase8 / 6.01 / Utility Trench Edge Surface | 0.802584 | 10.0163 | 7.96192
Trase9 / -7.01 / Utility Trench Edge Surface | Trase9/ROADSIDE | Utility Trench Edge Surface | -7.01 | Trase9 / -7.01 / Utility Trench Edge Surface | 0.001 | 6.00574 | 0.413267
Trase9 / 6.01 / Utility Trench Edge Surface | Trase9/ROADSIDE | Utility Trench Edge Surface | 6.01 | Trase9 / 6.01 / Utility Trench Edge Surface | 0.194724 | 6.0426 | 0.725216
Trase9 / -6.01 / Utility Trench Edge Surface | Trase9/ROADSIDE | Utility Trench Edge Surface | -6.01 | Trase9 / -6.01 / Utility Trench Edge Surface | 0.191724 | 3.03694 | 0.621216
Trase9 / 4.01 / Utility Trench Bottom | Trase9/ROADSIDE | Utility Trench Bottom | 4.01 | Trase9 / 4.01 / Utility Trench Bottom | 0.001 | 3.04001 | 0.00304
Trase9 / -6.01 / Utility Trench Edge Surface | Trase9/ROADSIDE | Utility Trench Edge Surface | -6.01 | Trase9 / -6.01 / Utility Trench Edge Surface | 0.257578 | 4.06237 | 1.06078
Trase9 / 7.01 / Utility Trench Edge Surface | Trase9/ROADSIDE | Utility Trench Edge Surface | 7.01 | Trase9 / 7.01 / Utility Trench Edge Surface | 0.001 | 3.00043 | 0.0497735
Trase9 / 6.01 / Utility Trench Edge Surface | Trase9/ROADSIDE | Utility Trench Edge Surface | 6.01 | Trase9 / 6.01 / Utility Trench Edge Surface | 0.262559 | 4.08218 | 1.0712
Trase9 / -4.01 / Utility Trench Bottom | Trase9/ROADSIDE | Utility Trench Bottom | -4.01 | Trase9 / -4.01 / Utility Trench Bottom | 3.04 | 3.04001 | 0.00304

# IfcDistributionChamberElement: ADJUSTINGUNIT, m-f_VA, O1
In: STORMWATER
Description: Manhole Adjusting Unit; PredefinedType: USERDEFINED
Common - ManholeID: WxEvytnDwUqwhXPG1TxPWA==:286; FEATURETYPE: AdjustingUnit; ManholeMaterial: Betong; ManholeNameAbbr: O; ManholeMaterialAbbr: BTG; ManholeTaperDiameter: 650; ManholeAdjustingHeight: 100; UtilityNetworkType: WS_StormwaterPipeNetwork; WSModelTaskGUID: WxEvytnDwUqwhXPG1TxPWA==; FeatureName: O1
Novapoint UtilityNetwork - Bruksomraade: Inspeksjonskum; ManholeAdjustingUnitHeight: 100; ManholeMateriale: Betong; ManholeTaperDiameter: 650; UtilityNetworkType: WS_StormwaterPipeNetwork; ManholeElevationAtTop: 32.8407; ManholeHasLadder: 0; ManholeHeight: 1.14045; Diameter (DN): 1000
TRMB_QUADRI_Qto_BaseQuantities - Volume: 0.0192643 m3; Height: 0.1 m; LongestHorizontalLength: 2.60597 m; ProjectedAreaInTheHorizontalPlane: 0.20909 m2

# IfcDistributionChamberElement: BASESHAFT (9)
Description: Manhole Base Shaft; PredefinedType: USERDEFINED
Common - FEATURETYPE: BaseShaft; ManholeMaterial: Betong; ManholeMaterialAbbr: BTG; ManholeIsInsideDimension: 1; ManholeMaterialThickness: 90; WSModelTaskGUID: WxEvytnDwUqwhXPG1TxPWA==
Novapoint UtilityNetwork - ManholeMateriale: Betong
Name | In | ManholeID | ManholeDiameter = Diameter (DN) | ManholeNameAbbr | ManholeBottomThickness | Common, ManholeInnerBottomZ = Novapoint UtilityNetwork, ManholeInnerBottomZ | ManholeOuterBottomZ | Common, ManholeSumpDepth = Novapoint UtilityNetwork, ManholeSumpDepth | Common, UtilityNetworkType = Novapoint UtilityNetwork, UtilityNetworkType | FeatureName | ManholeElevationAtTop | ManholeHasLadder | ManholeHeight | Volume (m3) | Height (m) | LongestHorizontalLength (m) | ProjectedAreaInTheHorizontalPlane (m2)
m-f_VA, SF2 | STORMWATER | WxEvytnDwUqwhXPG1TxPWA==:668 | 1000 | SA | 100 | 31.5114 | 31.4114 | 1000 | WS_StormwaterPipeNetwork | SF2 | 33.8175 | 0 | 2.30606 | 0.512484 | 1.80606 | 3.70499 | 0.307983
m-f_VA, SF3 | STORMWATER | WxEvytnDwUqwhXPG1TxPWA==:661 | 1000 | SA | 100 | 31.7122 | 31.6122 | 1000 | WS_StormwaterPipeNetwork | SF3 | 34.1843 | 0 | 2.4721 | 0.5596 | 1.9721 | 3.70499 | 0.307983
m-f_VA, S1 | SEWAGE | WxEvytnDwUqwhXPG1TxPWA==:189 | 1200 | S | 100 | 31.072 | 30.972 | 0 | WS_SewerNetwork | S1 | 33.0277 | 1 | 1.95568 | 0.488852 | 1.45568 | 4.33295 | 0.364494 | Novapoint UtilityNetwork - Bruksomraade: Inspeksjonskum
m-f_VA, O1 | STORMWATER | WxEvytnDwUqwhXPG1TxPWA==:286 | 1000 | O | 100 | 31.7002 | 31.6002 | 0 | WS_StormwaterPipeNetwork | O1 | 32.8407 | 0 | 1.14045 | 0.153358 | 0.540453 | 3.70499 | 0.307983 | Novapoint UtilityNetwork - Bruksomraade: Inspeksjonskum
m-f_VA, SF1 | STORMWATER | WxEvytnDwUqwhXPG1TxPWA==:245 | 1000 | SAK | 100 | 31.34 | 31.24 | 1000 | WS_StormwaterPipeNetwork | SF1 | 33.3888 | 0 | 2.04886 | 0.439502 | 1.54886 | 3.70499 | 0.307983
m-f_VA, O2 | STORMWATER | WxEvytnDwUqwhXPG1TxPWA==:1629 | 1000 | O | 100 | 30.4304 | 30.3304 | 0 | WS_StormwaterPipeNetwork | O2 | 32.0582 | 0 | 1.6278 | 0.320022 | 1.1278 | 3.70499 | 0.307983 | Novapoint UtilityNetwork - Bruksomraade: Inspeksjonskum
m-f_VA, DR2 | WATERSUPPLY | WxEvytnDwUqwhXPG1TxPWA==:1744 | 1000 | DR | 100 | 44.5811 | 44.4811 | 0 | WS_DrainageNetwork | DR2 | 46.7915 | 0 | 2.21045 | 0.485356 | 1.71045 | 3.70499 | 0.307983
m-f_VA, DR1 | WATERSUPPLY | WxEvytnDwUqwhXPG1TxPWA==:1747 | 1000 | DR | 100 | 37.1641 | 37.0641 | 0 | WS_DrainageNetwork | DR1 | 39.907 | 0 | 2.74289 | 0.636438 | 2.24288 | 3.70499 | 0.307983
m-f_VA, S2 | SEWAGE | WxEvytnDwUqwhXPG1TxPWA==:-1977 | 1000 | S | 300 | 31.0794 | 30.7794 | 0 | WS_SewerNetwork | S2 | 32.886 | 0 | 1.80666 | 0.370777 | 1.30666 | 3.70499 | 0.307983 | Novapoint UtilityNetwork - Bruksomraade: Inspeksjonskum

# IfcDistributionChamberElement: BASESLAB (9)
Description: Manhole Base Slab; PredefinedType: USERDEFINED
Common - FEATURETYPE: BaseSlab; ManholeMaterial: Betong; ManholeMaterialAbbr: BTG; ManholeIsInsideDimension: 1; ManholeMaterialThickness: 90; WSModelTaskGUID: WxEvytnDwUqwhXPG1TxPWA==
Novapoint UtilityNetwork - ManholeMateriale: Betong
Name | In | ManholeID | ManholeDiameter = Diameter (DN) | ManholeNameAbbr | ManholeBottomThickness | Common, ManholeInnerBottomZ = Novapoint UtilityNetwork, ManholeInnerBottomZ | ManholeOuterBottomZ | Common, ManholeSumpDepth = Novapoint UtilityNetwork, ManholeSumpDepth | Common, UtilityNetworkType = Novapoint UtilityNetwork, UtilityNetworkType | FeatureName | ManholeElevationAtTop | ManholeHasLadder | ManholeHeight | Volume (m3) | Height (m) | LongestHorizontalLength (m) | ProjectedAreaInTheHorizontalPlane (m2)
m-f_VA, SF2 | STORMWATER | WxEvytnDwUqwhXPG1TxPWA==:668 | 1000 | SA | 100 | 31.5114 | 31.4114 | 1000 | WS_StormwaterPipeNetwork | SF2 | 33.8175 | 0 | 2.30606 | 0.100689 | 0.1 | 3.70499 | 1.09285
m-f_VA, SF3 | STORMWATER | WxEvytnDwUqwhXPG1TxPWA==:661 | 1000 | SA | 100 | 31.7122 | 31.6122 | 1000 | WS_StormwaterPipeNetwork | SF3 | 34.1843 | 0 | 2.4721 | 0.100689 | 0.1 | 3.70499 | 1.09285
m-f_VA, S1 | SEWAGE | WxEvytnDwUqwhXPG1TxPWA==:189 | 1200 | S | 100 | 31.072 | 30.972 | 0 | WS_SewerNetwork | S1 | 33.0277 | 1 | 1.95568 | 0.137714 | 0.1 | 4.33291 | 1.49471 | Novapoint UtilityNetwork - Bruksomraade: Inspeksjonskum
m-f_VA, O1 | STORMWATER | WxEvytnDwUqwhXPG1TxPWA==:286 | 1000 | O | 100 | 31.7002 | 31.6002 | 0 | WS_StormwaterPipeNetwork | O1 | 32.8407 | 0 | 1.14045 | 0.100689 | 0.1 | 3.70499 | 1.09285 | Novapoint UtilityNetwork - Bruksomraade: Inspeksjonskum
m-f_VA, SF1 | STORMWATER | WxEvytnDwUqwhXPG1TxPWA==:245 | 1000 | SAK | 100 | 31.34 | 31.24 | 1000 | WS_StormwaterPipeNetwork | SF1 | 33.3888 | 0 | 2.04886 | 0.100689 | 0.1 | 3.70499 | 1.09285
m-f_VA, O2 | STORMWATER | WxEvytnDwUqwhXPG1TxPWA==:1629 | 1000 | O | 100 | 30.4304 | 30.3304 | 0 | WS_StormwaterPipeNetwork | O2 | 32.0582 | 0 | 1.6278 | 0.100689 | 0.1 | 3.70499 | 1.09285 | Novapoint UtilityNetwork - Bruksomraade: Inspeksjonskum
m-f_VA, DR2 | WATERSUPPLY | WxEvytnDwUqwhXPG1TxPWA==:1744 | 1000 | DR | 100 | 44.5811 | 44.4811 | 0 | WS_DrainageNetwork | DR2 | 46.7915 | 0 | 2.21045 | 0.100689 | 0.1 | 3.70499 | 1.09285
m-f_VA, DR1 | WATERSUPPLY | WxEvytnDwUqwhXPG1TxPWA==:1747 | 1000 | DR | 100 | 37.1641 | 37.0641 | 0 | WS_DrainageNetwork | DR1 | 39.907 | 0 | 2.74289 | 0.100689 | 0.1 | 3.70499 | 1.09285
m-f_VA, S2 | SEWAGE | WxEvytnDwUqwhXPG1TxPWA==:-1977 | 1000 | S | 300 | 31.0794 | 30.7794 | 0 | WS_SewerNetwork | S2 | 32.886 | 0 | 1.80666 | 0.302068 | 0.3 | 3.70499 | 1.09285 | Novapoint UtilityNetwork - Bruksomraade: Inspeksjonskum

# IfcDistributionChamberElement: MANHOLECOVER (8)
Description: Manhole Cover; PredefinedType: USERDEFINED
Name | In | UtilityNetworkType | ManholeElevationAtTop | ManholeHasLadder | ManholeHeight | Diameter (DN)
m-f_VA, SF2 | STORMWATER | WS_StormwaterPipeNetwork | 33.8175 | 0 | 2.30606 | 1000
m-f_VA, SF3 | STORMWATER | WS_StormwaterPipeNetwork | 34.1843 | 0 | 2.4721 | 1000
m-f_VA, S1 | SEWAGE | WS_SewerNetwork | 33.0277 | 1 | 1.95568 | 1200
m-f_VA, O1 | STORMWATER | WS_StormwaterPipeNetwork | 32.8407 | 0 | 1.14045 | 1000
m-f_VA, SF1 | STORMWATER | WS_StormwaterPipeNetwork | 33.3888 | 0 | 2.04886 | 1000
m-f_VA, O2 | STORMWATER | WS_StormwaterPipeNetwork | 32.0582 | 0 | 1.6278 | 1000
m-f_VA, DR2 | WATERSUPPLY | WS_DrainageNetwork | 46.7915 | 0 | 2.21045 | 1000
m-f_VA, DR1 | WATERSUPPLY | WS_DrainageNetwork | 39.907 | 0 | 2.74289 | 1000

# IfcDistributionChamberElement: TAPER (9)
Description: Manhole Taper; PredefinedType: USERDEFINED
Common - FEATURETYPE: TaperUnit; ManholeMaterial: Betong; ManholeMaterialAbbr: BTG; ManholeTaperDiameter: 650; ManholeTaperHeight: 500; WSModelTaskGUID: WxEvytnDwUqwhXPG1TxPWA==
Novapoint UtilityNetwork - ManholeMateriale: Betong; ManholeTaperDiameter: 650
TRMB_QUADRI_Qto_BaseQuantities - Height: 0.5 m
Name | In | ManholeID | ManholeTaperLocationType | Common, UtilityNetworkType = Novapoint UtilityNetwork, UtilityNetworkType | FeatureName | ManholeElevationAtTop | ManholeHasLadder | ManholeHeight | Diameter (DN) | Volume (m3) | LongestHorizontalLength (m) | ProjectedAreaInTheHorizontalPlane (m2)
m-f_VA, S1 | SEWAGE | WxEvytnDwUqwhXPG1TxPWA==:189 | Centric | WS_SewerNetwork | S1 | 33.0277 | 1 | 1.95568 | 1200 | 0.167912 | 4.33295 | 1.08586
m-f_VA, O1 | STORMWATER | WxEvytnDwUqwhXPG1TxPWA==:286 | Noncentric | WS_StormwaterPipeNetwork | O1 | 32.8407 | 0 | 1.14045 | 1000 | 0.141879 | 3.74233 | 1.09281 | TRMB_QUADRI_Qto_BaseQuantities - ShortestHorizontalLength: 0.037439 m
m-f_VA, SF1 | STORMWATER | WxEvytnDwUqwhXPG1TxPWA==:245 | Noncentric | WS_StormwaterPipeNetwork | SF1 | 33.3888 | 0 | 2.04886 | 1000 | 0.141879 | 3.70502 | 1.09286
m-f_VA, SF2 | STORMWATER | WxEvytnDwUqwhXPG1TxPWA==:668 | Noncentric | WS_StormwaterPipeNetwork | SF2 | 33.8175 | 0 | 2.30606 | 1000 | 0.141879 | 3.74243 | 1.09285 | TRMB_QUADRI_Qto_BaseQuantities - ShortestHorizontalLength: 0.037439 m
m-f_VA, SF3 | STORMWATER | WxEvytnDwUqwhXPG1TxPWA==:661 | Noncentric | WS_StormwaterPipeNetwork | SF3 | 34.1843 | 0 | 2.4721 | 1000 | 0.141879 | 3.74241 | 1.09281 | TRMB_QUADRI_Qto_BaseQuantities - ShortestHorizontalLength: 0.037439 m
m-f_VA, O2 | STORMWATER | WxEvytnDwUqwhXPG1TxPWA==:1629 | Noncentric | WS_StormwaterPipeNetwork | O2 | 32.0582 | 0 | 1.6278 | 1000 | 0.141879 | 3.70501 | 1.09286
m-f_VA, DR2 | WATERSUPPLY | WxEvytnDwUqwhXPG1TxPWA==:1744 | Noncentric | WS_DrainageNetwork | DR2 | 46.7915 | 0 | 2.21045 | 1000 | 0.141879 | 3.70501 | 1.09286
m-f_VA, DR1 | WATERSUPPLY | WxEvytnDwUqwhXPG1TxPWA==:1747 | Noncentric | WS_DrainageNetwork | DR1 | 39.907 | 0 | 2.74289 | 1000 | 0.141879 | 3.70501 | 1.09286
m-f_VA, S2 | SEWAGE | WxEvytnDwUqwhXPG1TxPWA==:-1977 | Noncentric | WS_SewerNetwork | S2 | 32.886 | 0 | 1.80666 | 1000 | 0.141879 | 3.73132 | 1.09286 | TRMB_QUADRI_Qto_BaseQuantities - ShortestHorizontalLength: 0.0263342 m

# IfcEarthworksFill (8)
In: Trase5|WATER AND SEWER
PredefinedType: BACKFILL
Common - TYPEID: Back Fill; VIPSSURFACENO: TRENCH_BACKFILL_VOLUME
Name | VIPSSURFACENAME | Volume (m3) | Height (m) | ShortestHorizontalLength (m) | LongestHorizontalLength (m) | ProjectedAreaInTheHorizontalPlane (m2)
Trase5 / Back Fill / Solid | Trase5 / Back Fill / Solid | 0.22458 | 0.188796 | 1.31627 | 1.36309 | 1.82443
Trase4 / Back Fill / Solid | Trase4 / Back Fill / Solid | 10.7934 | 1.3521 | 0.0457419 | 27.2467 | 48.4012
Trase 1 / Back Fill / Solid | Trase 1 / Back Fill / Solid | 108.299 | 1.93801 | 0.0548472 | 38.8167 | 130.407
Trase 2 / Back Fill / Solid | Trase 2 / Back Fill / Solid | 126.098 | 2.48403 | 0.596482 | 62.4657 | 331.809
Trase6 / Back Fill / Solid | Trase6 / Back Fill / Solid | 0.36062 | 0.398174 | 0.0497953 | 1.63095 | 1.47549
Trase 3 / Back Fill / Solid | Trase 3 / Back Fill / Solid | 32.2607 | 1.92452 | 1.48461 | 16.1434 | 38.8299
Trase 3 / Back Fill / Solid | Trase 3 / Back Fill / Solid | 70.1345 | 10.4222 | 0.0988901 | 68.861 | 163.892
Trase8 / Back Fill / Solid | Trase8 / Back Fill / Solid | 17.3736 | 1.19203 | 2.23386 | 10.0172 | 21.8988

# IfcElementAssembly: MANHOLE (9)
PredefinedType: USERDEFINED
Name | In
m-f_VA, DR2/MANHOLE | WATERSUPPLY
m-f_VA, DR1/MANHOLE | WATERSUPPLY
m-f_VA, S1/MANHOLE | SEWAGE
m-f_VA, S2/MANHOLE | SEWAGE
m-f_VA, SF2/MANHOLE | STORMWATER
m-f_VA, O1/MANHOLE | STORMWATER
m-f_VA, SF3/MANHOLE | STORMWATER
m-f_VA, SF1/MANHOLE | STORMWATER
m-f_VA, O2/MANHOLE | STORMWATER

# IfcElementAssembly: PIPES (9)
PredefinedType: USERDEFINED
Name | In
m-f_VA, Trase 1/PIPES | SEWAGE
m-f_VA, Trase8/PIPES | SEWAGE
m-f_VA, Trase6/PIPES | STORMWATER
m-f_VA, Trase 2/PIPES | STORMWATER
m-f_VA, Trase5/PIPES | STORMWATER
m-f_VA, Trase4/PIPES | STORMWATER
m-f_VA, Trase 3/PIPES | STORMWATER
m-f_VA, Trase7/PIPES | STORMWATER
m-f_VA, Trase9/PIPES | STORMWATER

# IfcElementAssembly: TRENCH
In: Trase5|WATER AND SEWER
PredefinedType: USERDEFINED

# IfcFacilityPartCommon: SEWAGE
PredefinedType: USERDEFINED

# IfcFacilityPartCommon: STORMWATER
PredefinedType: USERDEFINED

# IfcFacilityPartCommon: SURVEY
PredefinedType: USERDEFINED

# IfcFacilityPartCommon: SURVEY_MANHOLE
PredefinedType: USERDEFINED

# IfcFacilityPartCommon: SURVEY_PIPE
PredefinedType: USERDEFINED

# IfcFacilityPartCommon: SURVEY_TRENCH
PredefinedType: USERDEFINED

# IfcFacilityPartCommon: WATERSUPPLY
PredefinedType: USERDEFINED

# IfcPipeSegment: SEWAGE_NOPRESSURE (5)
In: SEWAGE
Description: Sewage pipe - No pressure; PredefinedType: USERDEFINED
Novapoint UtilityNetwork - UtilityNetworkType: WS_SewerNetwork
Name | PipeClass | PipeDeltaZ | PipeGradient | PipeHorizontalLength | PipeMaterial | PipeWallThickness | Diameter (DN) | ToConnection
m-f_VA, Trase 1, Pumpeledning spillvann | PN10 SDR 21 | 0.000556 | 7.58228e-05 | 7.33289 | Polyvinylklorid uten mykner Trykkledning | 7.7 | 160 | m-f_VA. S1
m-f_VA, Trase 1, Pumpeledning spillvann | PN16 SDR 13.6 | 0.47466 | 0.0140313 | 33.8286 | Polyvinylklorid uten mykner Trykkledning | 11.8 | 160 | Novapoint UtilityNetwork - FromConnection: m-f_VA. S1
m-f_VA, Trase 1, Spillvannsledning | SN8 SDR 34 | 0.196574 | 0.0135728 | 14.483 | Polyvinylklorid uten mykner Trykkløs | 4.7 | 160 | m-f_VA. S1
m-f_VA, Trase 1, Pumpeledning spillvann | PN16 SDR 13.6 | -0.041285 | -0.00308384 | 13.3875 | Polyvinylklorid uten mykner Trykkledning | 11.8 | 160
m-f_VA, Trase8, Pumpeledning spillvann | SDR 33 | -0.072448 | -0.00723296 | 10.0164 | Polyvinylklorid uten mykner Trykkledning | 2.8 | 90 | m-f_VA. S2

# IfcPipeSegment: STORMWATER_NOPRESSURE (10)
In: STORMWATER
Description: Stormwater pipe - No pressure; PredefinedType: USERDEFINED
Novapoint Utility - pressureRate: Gravity; pipelineShape: Round
Name | PipeClass | PipeDeltaZ | PipeGradient | PipeHorizontalLength | PipeMaterial = userdefinedMaterialType | PipeWallThickness | UtilityNetworkType | Diameter (DN) = exteriorDiameter = diamaterNominal | interiorDiameter | utilityNetworkUsage | constructionMaterial | textureName | ToConnection
m-f_VA, Trase 2, Overvannsledning | SN8 | -0.668767 | -0.010142 | 65.9407 | Dobbeltveggede overvannsrør | 21.5 | WS_StormwaterPipeNetwork | 250 | 207 | Stormwater | 103 | T_Plastic12 | Novapoint UtilityNetwork - FromConnection: m-f_VA. O1
m-f_VA, Trase5, Overvannsledning | SN8 SDR 34 | 0.080091 | 0.058782 | 1.36251 | Polyvinylklorid uten mykner Trykkløs | 4.7 | WS_StormwaterPipeNetwork | 160 | 150.6 | Stormwater | 112 |  | m-f_VA. SF2
m-f_VA, Trase4, Overvannsledning | SN8 SDR 34 | 0.323129 | 0.0100098 | 32.2813 | Polyvinylklorid uten mykner Trykkløs | 4.7 | WS_StormwaterPipeNetwork | 160 | 150.6 | Stormwater | 112 |  | m-f_VA. SF3 | Novapoint UtilityNetwork - FromConnection: m-f_VA. SF1
m-f_VA, Trase 2, Overvannsledning | SN8 | -0.639747 | -0.021789 | 29.361 | Dobbeltveggede overvannsrør | 21.5 | WS_StormwaterPipeNetwork | 250 | 207 | Stormwater | 103 | T_Plastic12 | m-f_VA. O1 | Novapoint UtilityNetwork - FromConnection: m-f_VA. SF1
m-f_VA, Trase6, Drensledning | SN8 | 0.630212 | 0.0234973 | 26.8207 | Dobbeltveggede drensrør | 13.5 | WS_DrainageNetwork | 150 | 123 | Drainage | 103 | T_Plastic12
m-f_VA, Trase7, Drensledning | SN8 | 1.05063 | 0.136743 | 7.68324 | Dobbeltveggede drensrør | 13.5 | WS_DrainageNetwork | 150 | 123 | Drainage | 103 | T_Plastic12
m-f_VA, Trase 3, Overvannsledning | SN8 | 0.16468 | 0.0102382 | 16.0849 | Dobbeltveggede overvannsrør | 21.5 | WS_StormwaterPipeNetwork | 250 | 207 | Stormwater | 103 | T_Plastic12 | m-f_VA. O2
m-f_VA, Trase 3, Drensledning | SN8 | 6.73374 | 0.0824071 | 81.7132 | Dobbeltveggede drensrør | 15.5 | WS_DrainageNetwork | 200 | 169 | Drainage | 103 | T_Plastic12 | m-f_VA. DR1 | Novapoint UtilityNetwork - FromConnection: m-f_VA. O2
m-f_VA, Trase 3, Drensledning | SN8 | 7.41698 | 0.0939191 | 78.972 | Dobbeltveggede drensrør | 13.5 | WS_DrainageNetwork | 150 | 123 | Drainage | 103 | T_Plastic12 | m-f_VA. DR2 | Novapoint UtilityNetwork - FromConnection: m-f_VA. DR1
m-f_VA, Trase9, Overvannsledning | SN8 | 0.951698 | 0.0790434 | 12.0402 | Dobbeltveggede overvannsrør | 27.5 | WS_StormwaterPipeNetwork | 315 | 260 | Stormwater | 103 | T_Plastic12

# IfcRoad: Road (9)
PredefinedType: USERDEFINED
Name
Trase5
Trase 1
Trase4
Trase6
Trase 2
Trase7
Trase 3
Trase9
Trase8

# IfcRoadPart (18)
Name | UsageType | PredefinedType
Trase5/ROADSEGMENT | LONGITUDINAL | ROADSEGMENT
Trase5/ROADSIDE | LATERAL | ROADSIDE
Trase 1/ROADSEGMENT | LONGITUDINAL | ROADSEGMENT
Trase 1/ROADSIDE | LATERAL | ROADSIDE
Trase4/ROADSEGMENT | LONGITUDINAL | ROADSEGMENT
Trase4/ROADSIDE | LATERAL | ROADSIDE
Trase6/ROADSEGMENT | LONGITUDINAL | ROADSEGMENT
Trase6/ROADSIDE | LATERAL | ROADSIDE
Trase 2/ROADSEGMENT | LONGITUDINAL | ROADSEGMENT
Trase 2/ROADSIDE | LATERAL | ROADSIDE
Trase7/ROADSEGMENT | LONGITUDINAL | ROADSEGMENT
Trase7/ROADSIDE | LATERAL | ROADSIDE
Trase 3/ROADSEGMENT | LONGITUDINAL | ROADSEGMENT
Trase 3/ROADSIDE | LATERAL | ROADSIDE
Trase9/ROADSEGMENT | LONGITUDINAL | ROADSEGMENT
Trase9/ROADSIDE | LATERAL | ROADSIDE
Trase8/ROADSEGMENT | LONGITUDINAL | ROADSEGMENT
Trase8/ROADSIDE | LATERAL | ROADSIDE
