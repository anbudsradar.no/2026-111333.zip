Properties of the parts of a building model (IFC4X3_ADD2), part 1 of 3

# File
Description: ViewDefinition [Alignment-basedView]
File name: C:\Users\leilar\AppData\Local\Temp\Trimble\ConnectFolder\m-f-va.ifc
Time: 2026-03-17T15:48:46
Author: Leif Gunnar Larsen
Organization: Statens vegvesen
Written by: Ifc Engine <1.0.1.1370>
Made in: Trimble Inc. - Novapoint - 28.0.290.0
Authorization: Leif Gunnar Larsen

# IfcSite (2)
Name
Default Site | RefLatitude: 10, 17, 30; RefLongitude: 63, 9, 16; RefElevation: 30.0931 m
Trase5

# IfcActor (2)
Name
 | Pset_Address - Purpose: OFFICE; Town: Bodø; Country: Norway


# IfcAnnotation: SURVEYPOINT_MANHOLE (44)
In: SURVEY_MANHOLE
PredefinedType: USERDEFINED
Name | Description
m-f_VA, SF2, InvertLevelPoint | InvertLevelPoint
m-f_VA, SF2, CentreLevelPoint | CentreLevelPoint
m-f_VA, SF2, CrownLevelPoint | CrownLevelPoint
m-f_VA, SF2, Bunnseksjon | BaseUnit | Common - ManholeID: WxEvytnDwUqwhXPG1TxPWA==:668; FEATURETYPE: BaseUnit; ManholeDiameter: 1000; ManholeMaterial: Betong; ManholeNameAbbr: SA; ManholeMaterialAbbr: BTG; ManholeIsInsideDimension: 1; ManholeMaterialThickness: 90; ManholeBottomThickness: 100; ManholeInnerBottomZ: 31.5114; ManholeOuterBottomZ: 31.4114; ManholeSumpDepth: 1000; UtilityNetworkType: WS_StormwaterPipeNetwork; WSModelTaskGUID: WxEvytnDwUqwhXPG1TxPWA==; FeatureName: SF2; Novapoint UtilityNetwork - ManholeInnerBottomZ: 31.5114; ManholeMateriale: Betong; ManholeSumpDepth: 1000; UtilityNetworkType: WS_StormwaterPipeNetwork
m-f_VA, SF3, InvertLevelPoint | InvertLevelPoint
m-f_VA, SF3, CentreLevelPoint | CentreLevelPoint
m-f_VA, SF3, CrownLevelPoint | CrownLevelPoint
m-f_VA, SF2, Lokk, center point | Manhole Cover Center Point | Common - ManholeID: WxEvytnDwUqwhXPG1TxPWA==:668; FEATURETYPE: ManholeCover; UtilityNetworkType: WS_StormwaterPipeNetwork; WSModelTaskGUID: WxEvytnDwUqwhXPG1TxPWA==; FeatureName: SF2; ManholeCoverType: SJK Rist; ManholeCoverHeight: 50; ManholeCoverCenterPoint: 89458.5.1.57423e+06.33.8175; TRMB_QUADRI_Qto_BaseQuantities - Volume: 0.0249084 m3; Height: 0.05 m; LongestHorizontalLength: 2.60597 m; ProjectedAreaInTheHorizontalPlane: 0.540698 m2
m-f_VA, SF3, Bunnseksjon | BaseUnit | Common - ManholeID: WxEvytnDwUqwhXPG1TxPWA==:661; FEATURETYPE: BaseUnit; ManholeDiameter: 1000; ManholeMaterial: Betong; ManholeNameAbbr: SA; ManholeMaterialAbbr: BTG; ManholeIsInsideDimension: 1; ManholeMaterialThickness: 90; ManholeBottomThickness: 100; ManholeInnerBottomZ: 31.7122; ManholeOuterBottomZ: 31.6122; ManholeSumpDepth: 1000; UtilityNetworkType: WS_StormwaterPipeNetwork; WSModelTaskGUID: WxEvytnDwUqwhXPG1TxPWA==; FeatureName: SF3; Novapoint UtilityNetwork - ManholeInnerBottomZ: 31.7122; ManholeMateriale: Betong; ManholeSumpDepth: 1000; UtilityNetworkType: WS_StormwaterPipeNetwork
m-f_VA, SF3, Lokk, center point | Manhole Cover Center Point | Common - ManholeID: WxEvytnDwUqwhXPG1TxPWA==:661; FEATURETYPE: ManholeCover; UtilityNetworkType: WS_StormwaterPipeNetwork; WSModelTaskGUID: WxEvytnDwUqwhXPG1TxPWA==; FeatureName: SF3; ManholeCoverType: SJK Rist; ManholeCoverHeight: 30; ManholeCoverCenterPoint: 89439.1.1.57421e+06.34.1843; TRMB_QUADRI_Qto_BaseQuantities - Volume: 0.0149451 m3; Height: 0.03 m; LongestHorizontalLength: 2.60597 m; ProjectedAreaInTheHorizontalPlane: 0.540698 m2
m-f_VA, S1, InvertLevelPoint | InvertLevelPoint
m-f_VA, S1, CentreLevelPoint | CentreLevelPoint
m-f_VA, S1, CrownLevelPoint | CrownLevelPoint
m-f_VA, S1, Bunnseksjon | BaseUnit | Common - ManholeID: WxEvytnDwUqwhXPG1TxPWA==:189; FEATURETYPE: BaseUnit; ManholeDiameter: 1200; ManholeMaterial: Betong; ManholeNameAbbr: S; ManholeMaterialAbbr: BTG; ManholeIsInsideDimension: 1; ManholeMaterialThickness: 90; ManholeBottomThickness: 100; ManholeInnerBottomZ: 31.072; ManholeOuterBottomZ: 30.972; ManholeSumpDepth: 0; UtilityNetworkType: WS_SewerNetwork; WSModelTaskGUID: WxEvytnDwUqwhXPG1TxPWA==; FeatureName: S1; Novapoint UtilityNetwork - ManholeInnerBottomZ: 31.072; ManholeMateriale: Betong; ManholeSumpDepth: 0; UtilityNetworkType: WS_SewerNetwork; Bruksomraade: Inspeksjonskum
m-f_VA, S1, Lokk, center point | Manhole Cover Center Point | Common - ManholeID: WxEvytnDwUqwhXPG1TxPWA==:189; FEATURETYPE: ManholeCover; UtilityNetworkType: WS_SewerNetwork; WSModelTaskGUID: WxEvytnDwUqwhXPG1TxPWA==; FeatureName: S1; ManholeCoverType: SJK; ManholeCoverHeight: 30; ManholeCoverCenterPoint: 89460.8.1.57426e+06.33.0277; TRMB_QUADRI_Qto_BaseQuantities - Volume: 0.0149451 m3; Height: 0.03 m; LongestHorizontalLength: 2.60597 m; ProjectedAreaInTheHorizontalPlane: 0.540698 m2
m-f_VA, O1, InvertLevelPoint | InvertLevelPoint
m-f_VA, O1, CentreLevelPoint | CentreLevelPoint
m-f_VA, O1, CrownLevelPoint | CrownLevelPoint
m-f_VA, O1, Bunnseksjon | BaseUnit | Common - ManholeID: WxEvytnDwUqwhXPG1TxPWA==:286; FEATURETYPE: BaseUnit; ManholeDiameter: 1000; ManholeMaterial: Betong; ManholeNameAbbr: O; ManholeMaterialAbbr: BTG; ManholeIsInsideDimension: 1; ManholeMaterialThickness: 90; ManholeBottomThickness: 100; ManholeInnerBottomZ: 31.7002; ManholeOuterBottomZ: 31.6002; ManholeSumpDepth: 0; UtilityNetworkType: WS_StormwaterPipeNetwork; WSModelTaskGUID: WxEvytnDwUqwhXPG1TxPWA==; FeatureName: O1; Novapoint UtilityNetwork - ManholeInnerBottomZ: 31.7002; ManholeMateriale: Betong; ManholeSumpDepth: 0; UtilityNetworkType: WS_StormwaterPipeNetwork; Bruksomraade: Inspeksjonskum
m-f_VA, O1, Lokk, center point | Manhole Cover Center Point | Common - ManholeID: WxEvytnDwUqwhXPG1TxPWA==:286; FEATURETYPE: ManholeCover; UtilityNetworkType: WS_StormwaterPipeNetwork; WSModelTaskGUID: WxEvytnDwUqwhXPG1TxPWA==; FeatureName: O1; ManholeCoverType: SJK; ManholeCoverHeight: 30; ManholeCoverCenterPoint: 89457.8.1.57426e+06.32.8407; TRMB_QUADRI_Qto_BaseQuantities - Volume: 0.0149451 m3; Height: 0.03 m; LongestHorizontalLength: 2.60597 m; ProjectedAreaInTheHorizontalPlane: 0.540698 m2
m-f_VA, SF1, InvertLevelPoint | InvertLevelPoint
m-f_VA, SF1, CentreLevelPoint | CentreLevelPoint
m-f_VA, SF1, CrownLevelPoint | CrownLevelPoint
m-f_VA, SF1, Bunnseksjon | BaseUnit | Common - ManholeID: WxEvytnDwUqwhXPG1TxPWA==:245; FEATURETYPE: BaseUnit; ManholeDiameter: 1000; ManholeMaterial: Betong; ManholeNameAbbr: SAK; ManholeMaterialAbbr: BTG; ManholeIsInsideDimension: 1; ManholeMaterialThickness: 90; ManholeBottomThickness: 100; ManholeInnerBottomZ: 31.34; ManholeOuterBottomZ: 31.24; ManholeSumpDepth: 1000; UtilityNetworkType: WS_StormwaterPipeNetwork; WSModelTaskGUID: WxEvytnDwUqwhXPG1TxPWA==; FeatureName: SF1; Novapoint UtilityNetwork - ManholeInnerBottomZ: 31.34; ManholeMateriale: Betong; ManholeSumpDepth: 1000; UtilityNetworkType: WS_StormwaterPipeNetwork
m-f_VA, SF1, Lokk, center point | Manhole Cover Center Point | Common - ManholeID: WxEvytnDwUqwhXPG1TxPWA==:245; FEATURETYPE: ManholeCover; UtilityNetworkType: WS_StormwaterPipeNetwork; WSModelTaskGUID: WxEvytnDwUqwhXPG1TxPWA==; FeatureName: SF1; ManholeCoverType: SJK Kuppelrist; ManholeCoverHeight: 120; ManholeCoverCenterPoint: 89464.8.1.57423e+06.33.3888; TRMB_QUADRI_Qto_BaseQuantities - Volume: 0.0777143 m3; Height: 0.12 m; LongestHorizontalLength: 2.606 m; ProjectedAreaInTheHorizontalPlane: 0.540676 m2
m-f_VA, O2, InvertLevelPoint | InvertLevelPoint
m-f_VA, O2, CentreLevelPoint | CentreLevelPoint
m-f_VA, O2, CrownLevelPoint | CrownLevelPoint
m-f_VA, O2, Bunnseksjon | BaseUnit | Common - ManholeID: WxEvytnDwUqwhXPG1TxPWA==:1629; FEATURETYPE: BaseUnit; ManholeDiameter: 1000; ManholeMaterial: Betong; ManholeNameAbbr: O; ManholeMaterialAbbr: BTG; ManholeIsInsideDimension: 1; ManholeMaterialThickness: 90; ManholeBottomThickness: 100; ManholeInnerBottomZ: 30.4304; ManholeOuterBottomZ: 30.3304; ManholeSumpDepth: 0; UtilityNetworkType: WS_StormwaterPipeNetwork; WSModelTaskGUID: WxEvytnDwUqwhXPG1TxPWA==; FeatureName: O2; Novapoint UtilityNetwork - ManholeInnerBottomZ: 30.4304; ManholeMateriale: Betong; ManholeSumpDepth: 0; UtilityNetworkType: WS_StormwaterPipeNetwork; Bruksomraade: Inspeksjonskum
m-f_VA, O2, Lokk, center point | Manhole Cover Center Point | Common - ManholeID: WxEvytnDwUqwhXPG1TxPWA==:1629; FEATURETYPE: ManholeCover; UtilityNetworkType: WS_StormwaterPipeNetwork; WSModelTaskGUID: WxEvytnDwUqwhXPG1TxPWA==; FeatureName: O2; ManholeCoverType: SJK; ManholeCoverHeight: 30; ManholeCoverCenterPoint: 89507.8.1.57435e+06.32.0582; TRMB_QUADRI_Qto_BaseQuantities - Volume: 0.0149451 m3; Height: 0.03 m; LongestHorizontalLength: 2.60597 m; ProjectedAreaInTheHorizontalPlane: 0.540698 m2
m-f_VA, DR2, InvertLevelPoint | InvertLevelPoint
m-f_VA, DR2, CentreLevelPoint | CentreLevelPoint
m-f_VA, DR2, CrownLevelPoint | CrownLevelPoint
m-f_VA, DR2, Bunnseksjon | BaseUnit | Common - ManholeID: WxEvytnDwUqwhXPG1TxPWA==:1744; FEATURETYPE: BaseUnit; ManholeDiameter: 1000; ManholeMaterial: Betong; ManholeNameAbbr: DR; ManholeMaterialAbbr: BTG; ManholeIsInsideDimension: 1; ManholeMaterialThickness: 90; ManholeBottomThickness: 100; ManholeInnerBottomZ: 44.5811; ManholeOuterBottomZ: 44.4811; ManholeSumpDepth: 0; UtilityNetworkType: WS_DrainageNetwork; WSModelTaskGUID: WxEvytnDwUqwhXPG1TxPWA==; FeatureName: DR2; Novapoint UtilityNetwork - ManholeInnerBottomZ: 44.5811; ManholeMateriale: Betong; ManholeSumpDepth: 0; UtilityNetworkType: WS_DrainageNetwork
m-f_VA, DR2, Lokk, center point | Manhole Cover Center Point | Common - ManholeID: WxEvytnDwUqwhXPG1TxPWA==:1744; FEATURETYPE: ManholeCover; UtilityNetworkType: WS_DrainageNetwork; WSModelTaskGUID: WxEvytnDwUqwhXPG1TxPWA==; FeatureName: DR2; ManholeCoverType: SJK; ManholeCoverHeight: 30; ManholeCoverCenterPoint: 89567.8.1.57448e+06.46.7915; TRMB_QUADRI_Qto_BaseQuantities - Volume: 0.0149451 m3; Height: 0.03 m; LongestHorizontalLength: 2.60597 m; ProjectedAreaInTheHorizontalPlane: 0.540698 m2
m-f_VA, DR1, InvertLevelPoint | InvertLevelPoint
m-f_VA, DR1, CentreLevelPoint | CentreLevelPoint
m-f_VA, DR1, CrownLevelPoint | CrownLevelPoint
m-f_VA, DR1, Bunnseksjon | BaseUnit | Common - ManholeID: WxEvytnDwUqwhXPG1TxPWA==:1747; FEATURETYPE: BaseUnit; ManholeDiameter: 1000; ManholeMaterial: Betong; ManholeNameAbbr: DR; ManholeMaterialAbbr: BTG; ManholeIsInsideDimension: 1; ManholeMaterialThickness: 90; ManholeBottomThickness: 100; ManholeInnerBottomZ: 37.1641; ManholeOuterBottomZ: 37.0641; ManholeSumpDepth: 0; UtilityNetworkType: WS_DrainageNetwork; WSModelTaskGUID: WxEvytnDwUqwhXPG1TxPWA==; FeatureName: DR1; Novapoint UtilityNetwork - ManholeInnerBottomZ: 37.1641; ManholeMateriale: Betong; ManholeSumpDepth: 0; UtilityNetworkType: WS_DrainageNetwork
m-f_VA, DR1, Lokk, center point | Manhole Cover Center Point | Common - ManholeID: WxEvytnDwUqwhXPG1TxPWA==:1747; FEATURETYPE: ManholeCover; UtilityNetworkType: WS_DrainageNetwork; WSModelTaskGUID: WxEvytnDwUqwhXPG1TxPWA==; FeatureName: DR1; ManholeCoverType: SJK; ManholeCoverHeight: 50; ManholeCoverCenterPoint: 89538.3.1.57441e+06.39.907; TRMB_QUADRI_Qto_BaseQuantities - Volume: 0.0249084 m3; Height: 0.05 m; LongestHorizontalLength: 2.60597 m; ProjectedAreaInTheHorizontalPlane: 0.540698 m2
m-f_VA, S2, InvertLevelPoint | InvertLevelPoint
m-f_VA, S2, CentreLevelPoint | CentreLevelPoint
m-f_VA, S2, CrownLevelPoint | CrownLevelPoint
m-f_VA, S2, Bunnseksjon | BaseUnit | Common - ManholeID: WxEvytnDwUqwhXPG1TxPWA==:-1977; FEATURETYPE: BaseUnit; ManholeDiameter: 1000; ManholeMaterial: Betong; ManholeNameAbbr: S; ManholeMaterialAbbr: BTG; ManholeIsInsideDimension: 1; ManholeMaterialThickness: 90; ManholeBottomThickness: 300; ManholeInnerBottomZ: 31.0794; ManholeOuterBottomZ: 30.7794; ManholeSumpDepth: 0; UtilityNetworkType: WS_SewerNetwork; WSModelTaskGUID: WxEvytnDwUqwhXPG1TxPWA==; FeatureName: S2; Novapoint UtilityNetwork - ManholeInnerBottomZ: 31.0794; ManholeMateriale: Betong; ManholeSumpDepth: 0; UtilityNetworkType: WS_SewerNetwork; Bruksomraade: Inspeksjonskum

# IfcAnnotation: SURVEYSTRINGLINE_MANHOLE (18)
In: SURVEY_MANHOLE
PredefinedType: USERDEFINED
Name | Description
m-f_VA, SF2, LineFromInsideBottom | LineFromInsideBottom
m-f_VA, SF2, LineFromOutsideBottom | LineFromOutsideBottom | Common - ManholeID: WxEvytnDwUqwhXPG1TxPWA==:668; FEATURETYPE: Manhole; ManholeDiameter: 1000; ManholeHeight: 2.30606; ManholeMaterial: Betong; ManholeNameAbbr: SA; ManholeMaterialAbbr: BTG; ManholeCoverType: SJK Rist; ManholeCoverHeight: 50; ManholeTaperDiameter: 650; ManholeTaperHeight: 500; ManholeTaperLocationType: Noncentric; ManholeAdjustingHeight: 0; ManholeIsInsideDimension: 1; ManholeMaterialThickness: 90; ManholeBottomThickness: 100; ManholeElevationAtTop: 33.8175; ManholeRotationAngle: -1.63011; ManholeCoverCenterPoint: 89458.5.1.57423e+06.33.8175; ManholeInnerBottomZ: 31.5114; ManholeOuterBottomZ: 31.4114; ManholeSumpDepth: 1000; ManholeHasLadder: 0; UtilityNetworkType: WS_StormwaterPipeNetwork; WSModelTaskGUID: WxEvytnDwUqwhXPG1TxPWA==; ManholeOutletZ: 32.5114; ManholeType: Sandfangsluk; FeatureName: SF2; QuadriDesignProperties - name: SF2; FEATURETYPE: Manhole; ManholeAdjustingHeight: 0; ManholeBottomThickness: 100; ManholeCoverCenterPoint: 89458.5.1.57423e+06.33.8175; ManholeCoverHeight: 50; ManholeCoverType: SJK Rist; ManholeDiameter: 1000; ManholeElevationAtTop: 33.8175; ManholeHasLadder: 0; ManholeHeight: 2.30606; ManholeID: WxEvytnDwUqwhXPG1TxPWA==:668; ManholeInnerBottomZ: 31.5114; ManholeIsInsideDimension: 1; ManholeMaterial: Betong; ManholeMaterialAbbr: BTG; ManholeMaterialThickness: 90; ManholeNameAbbr: SA; ManholeOuterBottomZ: 31.4114; ManholeRotationAngle: -1.63011; ManholeSumpDepth: 1000; ManholeTaperDiameter: 650; ManholeTaperHeight: 500; ManholeTaperLocationType: Noncentric; UtilityNetworkType: WS_StormwaterPipeNetwork; WSModelTaskGUID: WxEvytnDwUqwhXPG1TxPWA==; hasLadder: no; manholeConstruction: 1; diameterNominal: 1000; utilityNetworkUsage: 4; constructionMaterial: 1; textureName: T_Concrete01; userdefinedMaterialType: Betong; liableDisipline: WATERSEWER
m-f_VA, SF3, LineFromInsideBottom | LineFromInsideBottom
m-f_VA, SF3, LineFromOutsideBottom | LineFromOutsideBottom | Common - ManholeID: WxEvytnDwUqwhXPG1TxPWA==:661; FEATURETYPE: Manhole; ManholeDiameter: 1000; ManholeHeight: 2.4721; ManholeMaterial: Betong; ManholeNameAbbr: SA; ManholeMaterialAbbr: BTG; ManholeCoverType: SJK Rist; ManholeCoverHeight: 30; ManholeTaperDiameter: 650; ManholeTaperHeight: 500; ManholeTaperLocationType: Noncentric; ManholeAdjustingHeight: 0; ManholeIsInsideDimension: 1; ManholeMaterialThickness: 90; ManholeBottomThickness: 100; ManholeElevationAtTop: 34.1843; ManholeRotationAngle: -2.30309; ManholeCoverCenterPoint: 89439.1.1.57421e+06.34.1843; ManholeInnerBottomZ: 31.7122; ManholeOuterBottomZ: 31.6122; ManholeSumpDepth: 1000; ManholeHasLadder: 0; UtilityNetworkType: WS_StormwaterPipeNetwork; WSModelTaskGUID: WxEvytnDwUqwhXPG1TxPWA==; ManholeOutletZ: 32.7122; ManholeType: Sandfangsluk; FeatureName: SF3; QuadriDesignProperties - name: SF3; FEATURETYPE: Manhole; ManholeAdjustingHeight: 0; ManholeBottomThickness: 100; ManholeCoverCenterPoint: 89439.1.1.57421e+06.34.1843; ManholeCoverHeight: 30; ManholeCoverType: SJK Rist; ManholeDiameter: 1000; ManholeElevationAtTop: 34.1843; ManholeHasLadder: 0; ManholeHeight: 2.4721; ManholeID: WxEvytnDwUqwhXPG1TxPWA==:661; ManholeInnerBottomZ: 31.7122; ManholeIsInsideDimension: 1; ManholeMaterial: Betong; ManholeMaterialAbbr: BTG; ManholeMaterialThickness: 90; ManholeNameAbbr: SA; ManholeOuterBottomZ: 31.6122; ManholeRotationAngle: -2.30309; ManholeSumpDepth: 1000; ManholeTaperDiameter: 650; ManholeTaperHeight: 500; ManholeTaperLocationType: Noncentric; UtilityNetworkType: WS_StormwaterPipeNetwork; WSModelTaskGUID: WxEvytnDwUqwhXPG1TxPWA==; hasLadder: no; manholeConstruction: 1; diameterNominal: 1000; utilityNetworkUsage: 4; constructionMaterial: 1; textureName: T_Concrete01; userdefinedMaterialType: Betong; liableDisipline: WATERSEWER
m-f_VA, S1, LineFromInsideBottom | LineFromInsideBottom
m-f_VA, S1, LineFromOutsideBottom | LineFromOutsideBottom | Common - ManholeID: WxEvytnDwUqwhXPG1TxPWA==:189; FEATURETYPE: Manhole; ManholeDiameter: 1200; ManholeHeight: 1.95568; ManholeMaterial: Betong; ManholeNameAbbr: S; ManholeMaterialAbbr: BTG; ManholeCoverType: SJK; ManholeCoverHeight: 30; ManholeTaperDiameter: 650; ManholeTaperHeight: 500; ManholeTaperLocationType: Centric; ManholeAdjustingHeight: 0; ManholeIsInsideDimension: 1; ManholeMaterialThickness: 90; ManholeBottomThickness: 100; ManholeElevationAtTop: 33.0277; ManholeRotationAngle: 0; ManholeCoverCenterPoint: 89460.8.1.57426e+06.33.0277; ManholeInnerBottomZ: 31.072; ManholeOuterBottomZ: 30.972; ManholeSumpDepth: 0; ManholeHasLadder: 1; UtilityNetworkType: WS_SewerNetwork; WSModelTaskGUID: WxEvytnDwUqwhXPG1TxPWA==; ManholeOutletZ: 31.0875; ManholeType: Spillvannskum; FeatureName: S1; ManholeDzInOut: 0.092235; ManholeInletZ: 31.1797; QuadriDesignProperties - name: S1; FEATURETYPE: Manhole; ManholeAdjustingHeight: 0; ManholeBottomThickness: 100; ManholeCoverCenterPoint: 89460.8.1.57426e+06.33.0277; ManholeCoverHeight: 30; ManholeCoverType: SJK; ManholeDiameter: 1200; ManholeElevationAtTop: 33.0277; ManholeHasLadder: 1; ManholeHeight: 1.95568; ManholeID: WxEvytnDwUqwhXPG1TxPWA==:189; ManholeInnerBottomZ: 31.072; ManholeIsInsideDimension: 1; ManholeMaterial: Betong; ManholeMaterialAbbr: BTG; ManholeMaterialThickness: 90; ManholeNameAbbr: S; ManholeOuterBottomZ: 30.972; ManholeRotationAngle: 0; ManholeSumpDepth: 0; ManholeTaperDiameter: 650; ManholeTaperHeight: 500; ManholeTaperLocationType: Centric; UtilityNetworkType: WS_SewerNetwork; WSModelTaskGUID: WxEvytnDwUqwhXPG1TxPWA==; hasLadder: yes; manholeConstruction: 1; diameterNominal: 1200; utilityNetworkUsage: 2; constructionMaterial: 1; textureName: T_Concrete01; userdefinedMaterialType: Betong; liableDisipline: WATERSEWER; ManholeDzInOut: 0.092235
m-f_VA, O1, LineFromInsideBottom | LineFromInsideBottom
m-f_VA, O1, LineFromOutsideBottom | LineFromOutsideBottom | Common - ManholeID: WxEvytnDwUqwhXPG1TxPWA==:286; FEATURETYPE: Manhole; ManholeDiameter: 1000; ManholeHeight: 1.14045; ManholeMaterial: Betong; ManholeNameAbbr: O; ManholeMaterialAbbr: BTG; ManholeCoverType: SJK; ManholeCoverHeight: 30; ManholeTaperDiameter: 650; ManholeTaperHeight: 500; ManholeTaperLocationType: Noncentric; ManholeAdjustingHeight: 100; ManholeIsInsideDimension: 1; ManholeMaterialThickness: 90; ManholeBottomThickness: 100; ManholeElevationAtTop: 32.8407; ManholeRotationAngle: 0.171247; ManholeCoverCenterPoint: 89457.8.1.57426e+06.32.8407; ManholeInnerBottomZ: 31.7002; ManholeOuterBottomZ: 31.6002; ManholeSumpDepth: 0; ManholeHasLadder: 0; UtilityNetworkType: WS_StormwaterPipeNetwork; WSModelTaskGUID: WxEvytnDwUqwhXPG1TxPWA==; ManholeOutletZ: 31.7002; ManholeType: Overvannskum; FeatureName: O1; ManholeDzInOut: 0; ManholeInletZ: 31.7002; QuadriDesignProperties - name: O1; FEATURETYPE: Manhole; ManholeAdjustingHeight: 100; ManholeBottomThickness: 100; ManholeCoverCenterPoint: 89457.8.1.57426e+06.32.8407; ManholeCoverHeight: 30; ManholeCoverType: SJK; ManholeDiameter: 1000; ManholeElevationAtTop: 32.8407; ManholeHasLadder: 0; ManholeHeight: 1.14045; ManholeID: WxEvytnDwUqwhXPG1TxPWA==:286; ManholeInnerBottomZ: 31.7002; ManholeIsInsideDimension: 1; ManholeMaterial: Betong; ManholeMaterialAbbr: BTG; ManholeMaterialThickness: 90; ManholeNameAbbr: O; ManholeOuterBottomZ: 31.6002; ManholeRotationAngle: 0.171247; ManholeSumpDepth: 0; ManholeTaperDiameter: 650; ManholeTaperHeight: 500; ManholeTaperLocationType: Noncentric; UtilityNetworkType: WS_StormwaterPipeNetwork; WSModelTaskGUID: WxEvytnDwUqwhXPG1TxPWA==; hasLadder: no; manholeConstruction: 1; diameterNominal: 1000; utilityNetworkUsage: 4; constructionMaterial: 1; textureName: T_Concrete01; userdefinedMaterialType: Betong; liableDisipline: WATERSEWER; ManholeDzInOut: 0; manholeType: 2
m-f_VA, SF1, LineFromInsideBottom | LineFromInsideBottom
m-f_VA, SF1, LineFromOutsideBottom | LineFromOutsideBottom | Common - ManholeID: WxEvytnDwUqwhXPG1TxPWA==:245; FEATURETYPE: Manhole; ManholeDiameter: 1000; ManholeHeight: 2.04886; ManholeMaterial: Betong; ManholeNameAbbr: SAK; ManholeMaterialAbbr: BTG; ManholeCoverType: SJK Kuppelrist; ManholeCoverHeight: 120; ManholeTaperDiameter: 650; ManholeTaperHeight: 500; ManholeTaperLocationType: Noncentric; ManholeAdjustingHeight: 0; ManholeIsInsideDimension: 1; ManholeMaterialThickness: 90; ManholeBottomThickness: 100; ManholeElevationAtTop: 33.3888; ManholeRotationAngle: -0.303591; ManholeCoverCenterPoint: 89464.8.1.57423e+06.33.3888; ManholeInnerBottomZ: 31.34; ManholeOuterBottomZ: 31.24; ManholeSumpDepth: 1000; ManholeHasLadder: 0; UtilityNetworkType: WS_StormwaterPipeNetwork; WSModelTaskGUID: WxEvytnDwUqwhXPG1TxPWA==; ManholeOutletZ: 32.34; ManholeType: Sandfangsluk m/kuppelrist; FeatureName: SF1; ManholeDzInOut: 0.049097; ManholeInletZ: 32.3891; QuadriDesignProperties - name: SF1; FEATURETYPE: Manhole; ManholeAdjustingHeight: 0; ManholeBottomThickness: 100; ManholeCoverCenterPoint: 89464.8.1.57423e+06.33.3888; ManholeCoverHeight: 120; ManholeCoverType: SJK Kuppelrist; ManholeDiameter: 1000; ManholeElevationAtTop: 33.3888; ManholeHasLadder: 0; ManholeHeight: 2.04886; ManholeID: WxEvytnDwUqwhXPG1TxPWA==:245; ManholeInnerBottomZ: 31.34; ManholeIsInsideDimension: 1; ManholeMaterial: Betong; ManholeMaterialAbbr: BTG; ManholeMaterialThickness: 90; ManholeNameAbbr: SAK; ManholeOuterBottomZ: 31.24; ManholeRotationAngle: -0.303591; ManholeSumpDepth: 1000; ManholeTaperDiameter: 650; ManholeTaperHeight: 500; ManholeTaperLocationType: Noncentric; UtilityNetworkType: WS_StormwaterPipeNetwork; WSModelTaskGUID: WxEvytnDwUqwhXPG1TxPWA==; hasLadder: no; manholeConstruction: 1; diameterNominal: 1000; utilityNetworkUsage: 4; constructionMaterial: 1; textureName: T_Concrete01; userdefinedMaterialType: Betong; liableDisipline: WATERSEWER; ManholeDzInOut: 0.049097; manholeType: 2
m-f_VA, O2, LineFromInsideBottom | LineFromInsideBottom
m-f_VA, O2, LineFromOutsideBottom | LineFromOutsideBottom | Common - ManholeID: WxEvytnDwUqwhXPG1TxPWA==:1629; FEATURETYPE: Manhole; ManholeDiameter: 1000; ManholeHeight: 1.6278; ManholeMaterial: Betong; ManholeNameAbbr: O; ManholeMaterialAbbr: BTG; ManholeCoverType: SJK; ManholeCoverHeight: 30; ManholeTaperDiameter: 650; ManholeTaperHeight: 500; ManholeTaperLocationType: Noncentric; ManholeAdjustingHeight: 0; ManholeIsInsideDimension: 1; ManholeMaterialThickness: 90; ManholeBottomThickness: 100; ManholeElevationAtTop: 32.0582; ManholeRotationAngle: 0; ManholeCoverCenterPoint: 89507.8.1.57435e+06.32.0582; ManholeInnerBottomZ: 30.4304; ManholeOuterBottomZ: 30.3304; ManholeSumpDepth: 0; ManholeHasLadder: 0; UtilityNetworkType: WS_StormwaterPipeNetwork; WSModelTaskGUID: WxEvytnDwUqwhXPG1TxPWA==; ManholeOutletZ: 30.4304; ManholeType: Overvannskum; FeatureName: O2; ManholeDzInOut: 0; ManholeInletZ: 30.4304; QuadriDesignProperties - name: O2; FEATURETYPE: Manhole; ManholeAdjustingHeight: 0; ManholeBottomThickness: 100; ManholeCoverCenterPoint: 89507.8.1.57435e+06.32.0582; ManholeCoverHeight: 30; ManholeCoverType: SJK; ManholeDiameter: 1000; ManholeElevationAtTop: 32.0582; ManholeHasLadder: 0; ManholeHeight: 1.6278; ManholeID: WxEvytnDwUqwhXPG1TxPWA==:1629; ManholeInnerBottomZ: 30.4304; ManholeIsInsideDimension: 1; ManholeMaterial: Betong; ManholeMaterialAbbr: BTG; ManholeMaterialThickness: 90; ManholeNameAbbr: O; ManholeOuterBottomZ: 30.3304; ManholeRotationAngle: 0; ManholeSumpDepth: 0; ManholeTaperDiameter: 650; ManholeTaperHeight: 500; ManholeTaperLocationType: Noncentric; UtilityNetworkType: WS_StormwaterPipeNetwork; WSModelTaskGUID: WxEvytnDwUqwhXPG1TxPWA==; hasLadder: no; manholeConstruction: 1; diameterNominal: 1000; utilityNetworkUsage: 4; constructionMaterial: 1; textureName: T_Concrete01; userdefinedMaterialType: Betong; liableDisipline: WATERSEWER; ManholeDzInOut: 0; manholeType: 2
m-f_VA, DR2, LineFromInsideBottom | LineFromInsideBottom
m-f_VA, DR2, LineFromOutsideBottom | LineFromOutsideBottom | Common - ManholeID: WxEvytnDwUqwhXPG1TxPWA==:1744; FEATURETYPE: Manhole; ManholeDiameter: 1000; ManholeHeight: 2.21045; ManholeMaterial: Betong; ManholeNameAbbr: DR; ManholeMaterialAbbr: BTG; ManholeCoverType: SJK; ManholeCoverHeight: 30; ManholeTaperDiameter: 650; ManholeTaperHeight: 500; ManholeTaperLocationType: Noncentric; ManholeAdjustingHeight: 0; ManholeIsInsideDimension: 1; ManholeMaterialThickness: 90; ManholeBottomThickness: 100; ManholeElevationAtTop: 46.7915; ManholeRotationAngle: 0; ManholeCoverCenterPoint: 89567.8.1.57448e+06.46.7915; ManholeInnerBottomZ: 44.5811; ManholeOuterBottomZ: 44.4811; ManholeSumpDepth: 0; ManholeHasLadder: 0; UtilityNetworkType: WS_DrainageNetwork; WSModelTaskGUID: WxEvytnDwUqwhXPG1TxPWA==; ManholeOutletZ: 44.5811; ManholeType: Drenskum; FeatureName: DR2; QuadriDesignProperties - name: DR2; FEATURETYPE: Manhole; ManholeAdjustingHeight: 0; ManholeBottomThickness: 100; ManholeCoverCenterPoint: 89567.8.1.57448e+06.46.7915; ManholeCoverHeight: 30; ManholeCoverType: SJK; ManholeDiameter: 1000; ManholeElevationAtTop: 46.7915; ManholeHasLadder: 0; ManholeHeight: 2.21045; ManholeID: WxEvytnDwUqwhXPG1TxPWA==:1744; ManholeInnerBottomZ: 44.5811; ManholeIsInsideDimension: 1; ManholeMaterial: Betong; ManholeMaterialAbbr: BTG; ManholeMaterialThickness: 90; ManholeNameAbbr: DR; ManholeOuterBottomZ: 44.4811; ManholeRotationAngle: 0; ManholeSumpDepth: 0; ManholeTaperDiameter: 650; ManholeTaperHeight: 500; ManholeTaperLocationType: Noncentric; UtilityNetworkType: WS_DrainageNetwork; WSModelTaskGUID: WxEvytnDwUqwhXPG1TxPWA==; hasLadder: no; manholeConstruction: 1; diameterNominal: 1000; utilityNetworkUsage: 5; constructionMaterial: 1; textureName: T_Concrete01; userdefinedMaterialType: Betong; liableDisipline: WATERSEWER; manholeType: 2
m-f_VA, DR1, LineFromInsideBottom | LineFromInsideBottom
m-f_VA, DR1, LineFromOutsideBottom | LineFromOutsideBottom | Common - ManholeID: WxEvytnDwUqwhXPG1TxPWA==:1747; FEATURETYPE: Manhole; ManholeDiameter: 1000; ManholeHeight: 2.74289; ManholeMaterial: Betong; ManholeNameAbbr: DR; ManholeMaterialAbbr: BTG; ManholeCoverType: SJK; ManholeCoverHeight: 50; ManholeTaperDiameter: 650; ManholeTaperHeight: 500; ManholeTaperLocationType: Noncentric; ManholeAdjustingHeight: 0; ManholeIsInsideDimension: 1; ManholeMaterialThickness: 90; ManholeBottomThickness: 100; ManholeElevationAtTop: 39.907; ManholeRotationAngle: 0; ManholeCoverCenterPoint: 89538.3.1.57441e+06.39.907; ManholeInnerBottomZ: 37.1641; ManholeOuterBottomZ: 37.0641; ManholeSumpDepth: 0; ManholeHasLadder: 0; UtilityNetworkType: WS_DrainageNetwork; WSModelTaskGUID: WxEvytnDwUqwhXPG1TxPWA==; ManholeOutletZ: 37.1641; ManholeType: Drenskum; FeatureName: DR1; ManholeDzInOut: 0; ManholeInletZ: 37.1641; QuadriDesignProperties - name: DR1; FEATURETYPE: Manhole; ManholeAdjustingHeight: 0; ManholeBottomThickness: 100; ManholeCoverCenterPoint: 89538.3.1.57441e+06.39.907; ManholeCoverHeight: 50; ManholeCoverType: SJK; ManholeDiameter: 1000; ManholeElevationAtTop: 39.907; ManholeHasLadder: 0; ManholeHeight: 2.74289; ManholeID: WxEvytnDwUqwhXPG1TxPWA==:1747; ManholeInnerBottomZ: 37.1641; ManholeIsInsideDimension: 1; ManholeMaterial: Betong; ManholeMaterialAbbr: BTG; ManholeMaterialThickness: 90; ManholeNameAbbr: DR; ManholeOuterBottomZ: 37.0641; ManholeRotationAngle: 0; ManholeSumpDepth: 0; ManholeTaperDiameter: 650; ManholeTaperHeight: 500; ManholeTaperLocationType: Noncentric; UtilityNetworkType: WS_DrainageNetwork; WSModelTaskGUID: WxEvytnDwUqwhXPG1TxPWA==; hasLadder: no; manholeConstruction: 1; diameterNominal: 1000; utilityNetworkUsage: 5; constructionMaterial: 1; textureName: T_Concrete01; userdefinedMaterialType: Betong; liableDisipline: WATERSEWER; ManholeDzInOut: 0; manholeType: 2
m-f_VA, S2, LineFromInsideBottom | LineFromInsideBottom
m-f_VA, S2, LineFromOutsideBottom | LineFromOutsideBottom | Common - ManholeID: WxEvytnDwUqwhXPG1TxPWA==:-1977; FEATURETYPE: Manhole; ManholeDiameter: 1000; ManholeHeight: 1.80666; ManholeMaterial: Betong; ManholeNameAbbr: S; ManholeMaterialAbbr: BTG; ManholeCoverHeight: 0; ManholeTaperDiameter: 650; ManholeTaperHeight: 500; ManholeTaperLocationType: Noncentric; ManholeAdjustingHeight: 0; ManholeIsInsideDimension: 1; ManholeMaterialThickness: 90; ManholeBottomThickness: 300; ManholeElevationAtTop: 32.886; ManholeRotationAngle: 0; ManholeCoverCenterPoint: 89450.2.1.57425e+06.32.886; ManholeInnerBottomZ: 31.0794; ManholeOuterBottomZ: 30.7794; ManholeSumpDepth: 0; ManholeHasLadder: 0; UtilityNetworkType: WS_SewerNetwork; WSModelTaskGUID: WxEvytnDwUqwhXPG1TxPWA==; ManholeType: Spillvannskum; FeatureName: S2; ManholeInletZ: 31.1822; QuadriDesignProperties - name: S2; FEATURETYPE: Manhole; ManholeAdjustingHeight: 0; ManholeBottomThickness: 300; ManholeCoverCenterPoint: 89450.2.1.57425e+06.32.886; ManholeCoverHeight: 0; ManholeDiameter: 1000; ManholeElevationAtTop: 32.886; ManholeHasLadder: 0; ManholeHeight: 1.80666; ManholeID: WxEvytnDwUqwhXPG1TxPWA==:-1977; ManholeInnerBottomZ: 31.0794; ManholeIsInsideDimension: 1; ManholeMaterial: Betong; ManholeMaterialAbbr: BTG; ManholeMaterialThickness: 90; ManholeNameAbbr: S; ManholeOuterBottomZ: 30.7794; ManholeRotationAngle: 0; ManholeSumpDepth: 0; ManholeTaperDiameter: 650; ManholeTaperHeight: 500; ManholeTaperLocationType: Noncentric; UtilityNetworkType: WS_SewerNetwork; WSModelTaskGUID: WxEvytnDwUqwhXPG1TxPWA==; hasLadder: no; manholeConstruction: 1; diameterNominal: 1000; utilityNetworkUsage: 2; constructionMaterial: 1; textureName: T_Concrete01; userdefinedMaterialType: Betong; liableDisipline: WATERSEWER

# IfcAnnotation: SURVEYSTRINGLINE_PIPE (15)
In: SURVEY_PIPE
Description: Reference line inside bottom; PredefinedType: USERDEFINED
Common - PipeIsInsideDimension: 0; CulvertType: 0; ProtectionType: 0; WSModelTaskGUID: WxEvytnDwUqwhXPG1TxPWA==
Name | FromConnection | ToConnection | PipeType | PipeMaterial | PipeNameAbbr | PipeMaterialAbbr | PipeHorizontalLength | PipeDeltaZ | PipeGradient | PipeGradientInPerThousand | PipeWallThickness | PipeClass | AutoCadColorIndex | PipeID | UtilityNetworkType | PipeLength3D | PipeStartZ | PipeEndZ | FromConnectionName | ToConnectionName | FeatureName | Volume (m3) | Height (m) | ShortestHorizontalLength (m) | LongestHorizontalLength (m) | ProjectedAreaInTheHorizontalPlane (m2)
m-f_VA, Trase 2, Overvannsledning | WxEvytnDwUqwhXPG1TxPWA==:286 | WxEvytnDwUqwhXPG1TxPWA==:517 | StormwaterPipe | Dobbeltveggede overvannsrør | OV | DVO | 65.9407 | -0.668767 | -0.010142 | -10.1 | 21.5 | SN8 | 7 | WxEvytnDwUqwhXPG1TxPWA==:458 | WS_StormwaterPipeNetwork | 65.9441 | 31.7002 | 31.0315 | O1 | Trasepunkt | Overvannsledning | 1.01709 | 0.918723 | 0.249719 | 65.9661 | 16.4839
m-f_VA, Trase5, Overvannsledning | WxEvytnDwUqwhXPG1TxPWA==:632 | WxEvytnDwUqwhXPG1TxPWA==:668 | StormwaterPipe | Polyvinylklorid uten mykner Trykkløs | OV | PVC-U | 1.36251 | 0.080091 | 0.058782 | 58.8 | 4.7 | SN8 SDR 34 | 7 | WxEvytnDwUqwhXPG1TxPWA==:666 | WS_StormwaterPipeNetwork | 1.36486 | 32.4313 | 32.5114 | Bend | SF2 | Overvannsledning | 0.00312764 | 0.239795 | 0.160051 | 1.3634 | 0.219126
m-f_VA, Trase4, Overvannsledning | WxEvytnDwUqwhXPG1TxPWA==:245 | WxEvytnDwUqwhXPG1TxPWA==:661 | StormwaterPipe | Polyvinylklorid uten mykner Trykkløs | OV | PVC-U | 32.2813 | 0.323129 | 0.0100098 | 10.0 | 4.7 | SN8 SDR 34 | 7 | WxEvytnDwUqwhXPG1TxPWA==:630 | WS_StormwaterPipeNetwork | 32.2829 | 32.3891 | 32.7122 | SF1 | SF3 | Overvannsledning | 0.0739775 | 0.483101 | 0.00151858 | 27.5236 | 5.16307
m-f_VA, Trase 1, Pumpeledning spillvann | WxEvytnDwUqwhXPG1TxPWA==:95 | WxEvytnDwUqwhXPG1TxPWA==:189 | SewerPipe | Polyvinylklorid uten mykner Trykkledning | PS | PVC-U | 7.33289 | 0.000556 | 7.58228e-05 | 0.1 | 7.7 | PN10 SDR 21 | 100 | WxEvytnDwUqwhXPG1TxPWA==:951 | WS_SewerNetwork | 7.33292 | 31.3315 | 31.332 | Trasepunkt13 | S1 | Pumpeledning spillvann | 0.0269976 | 0.170715 | 0.00103381 | 5.1687 | 1.17314
m-f_VA, Trase 1, Pumpeledning spillvann | WxEvytnDwUqwhXPG1TxPWA==:189 | WxEvytnDwUqwhXPG1TxPWA==:113 | SewerPipe | Polyvinylklorid uten mykner Trykkledning | PS | PVC-U | 33.8286 | 0.47466 | 0.0140313 | 14.0 | 11.8 | PN16 SDR 13.6 | 100 | WxEvytnDwUqwhXPG1TxPWA==:111 | WS_SewerNetwork | 33.8319 | 31.332 | 31.8067 | S1 | Trasepunkt16 | Pumpeledning spillvann | 0.185744 | 0.634624 | 0.159023 | 33.8288 | 5.40876
m-f_VA, Trase 1, Spillvannsledning | WxEvytnDwUqwhXPG1TxPWA==:124 | WxEvytnDwUqwhXPG1TxPWA==:189 | SewerPipe | Polyvinylklorid uten mykner Trykkløs | SP | PVC-U | 14.483 | 0.196574 | 0.0135728 | 13.6 | 4.7 | SN8 SDR 34 | 100 | WxEvytnDwUqwhXPG1TxPWA==:953 | WS_SewerNetwork | 14.4845 | 30.8909 | 31.0875 | Trasepunkt13 | S1 | Spillvannsledning | 0.0331918 | 0.356521 | 0.159721 | 9.56946 | 2.31704
m-f_VA, Trase 2, Overvannsledning | WxEvytnDwUqwhXPG1TxPWA==:245 | WxEvytnDwUqwhXPG1TxPWA==:286 | StormwaterPipe | Dobbeltveggede overvannsrør | OV | DVO | 29.361 | -0.639747 | -0.021789 | -21.8 | 21.5 | SN8 | 7 | WxEvytnDwUqwhXPG1TxPWA==:243 | WS_StormwaterPipeNetwork | 29.3681 | 32.34 | 31.7002 | SF1 | O1 | Overvannsledning | 0.452959 | 0.8897 | 0.249601 | 29.3626 | 7.33949
m-f_VA, Trase6, Drensledning | WxEvytnDwUqwhXPG1TxPWA==:1237 | WxEvytnDwUqwhXPG1TxPWA==:1253 | StormwaterPipe | Dobbeltveggede drensrør | DR | DVD | 26.8207 | 0.630212 | 0.0234973 | 23.5 | 13.5 | SN8 | 32 | WxEvytnDwUqwhXPG1TxPWA==:1235 | WS_DrainageNetwork | 26.8564 | 32.187 | 32.8172 | Trasepunkt | Trasepunkt | Drensledning | 0.155372 | 0.779968 | 0.00192201 | 26.8319 | 4.02532
m-f_VA, Trase7, Drensledning | WxEvytnDwUqwhXPG1TxPWA==:1406 | WxEvytnDwUqwhXPG1TxPWA==:1438 | StormwaterPipe | Dobbeltveggede drensrør | DR | DVD | 7.68324 | 1.05063 | 0.136743 | 136.7 | 13.5 | SN8 | 32 | WxEvytnDwUqwhXPG1TxPWA==:1404 | WS_DrainageNetwork | 8.0763 | 32.1655 | 33.2161 | Trasepunkt | Trasepunkt | Drensledning | 0.0467237 | 1.1969 | 0.14968 | 9.00888 | 1.18204
m-f_VA, Trase 1, Pumpeledning spillvann | WxEvytnDwUqwhXPG1TxPWA==:89 | WxEvytnDwUqwhXPG1TxPWA==:95 | SewerPipe | Polyvinylklorid uten mykner Trykkledning | PS | PVC-U | 13.3875 | -0.041285 | -0.00308384 | -3.1 | 11.8 | PN16 SDR 13.6 | 100 | WxEvytnDwUqwhXPG1TxPWA==:1099 | WS_SewerNetwork | 13.3876 | 31.3728 | 31.3315 | Trasepunkt11 | Trasepunkt13 | Pumpeledning spillvann | 0.0735007 | 0.201264 | 0.00142495 | 13.3876 | 2.14153
m-f_VA, Trase 3, Overvannsledning | WxEvytnDwUqwhXPG1TxPWA==:1626 | WxEvytnDwUqwhXPG1TxPWA==:1629 | StormwaterPipe | Dobbeltveggede overvannsrør | OV | DVO | 16.0849 | 0.16468 | 0.0102382 | 10.2 | 21.5 | SN8 | 7 | WxEvytnDwUqwhXPG1TxPWA==:1598 | WS_StormwaterPipeNetwork | 16.0857 | 30.2657 | 30.4304 | Trasepunkt31 | O2 | Overvannsledning | 0.248098 | 0.414635 | 0.249471 | 16.085 | 4.02071
m-f_VA, Trase 3, Drensledning | WxEvytnDwUqwhXPG1TxPWA==:1629 | WxEvytnDwUqwhXPG1TxPWA==:1747 | StormwaterPipe | Dobbeltveggede drensrør | DR | DVD | 81.7132 | 6.73374 | 0.0824071 | 82.4 | 15.5 | SN8 | 32 | WxEvytnDwUqwhXPG1TxPWA==:1632 | WS_DrainageNetwork | 82.5236 | 30.4304 | 37.1641 | O2 | DR1 | Drensledning | 0.740908 | 6.93068 | 0.199154 | 66.7594 | 28.6682
m-f_VA, Trase 3, Drensledning | WxEvytnDwUqwhXPG1TxPWA==:1747 | WxEvytnDwUqwhXPG1TxPWA==:1744 | StormwaterPipe | Dobbeltveggede drensrør | DR | DVD | 78.972 | 7.41698 | 0.0939191 | 93.9 | 13.5 | SN8 | 32 | WxEvytnDwUqwhXPG1TxPWA==:1685 | WS_DrainageNetwork | 79.4252 | 37.1641 | 44.5811 | DR1 | DR2 | Drensledning | 0.459498 | 7.56578 | 0.150839 | 73.1011 | 37.7893
m-f_VA, Trase8, Pumpeledning spillvann | WxEvytnDwUqwhXPG1TxPWA==:-1089 | WxEvytnDwUqwhXPG1TxPWA==:-1977 | SewerPipe | Polyvinylklorid uten mykner Trykkledning | PS | PVC-U | 10.0164 | -0.072448 | -0.00723296 | -7.2 | 2.8 | SDR 33 | 100 | WxEvytnDwUqwhXPG1TxPWA==:-1082 | WS_SewerNetwork | 10.0166 | 31.3418 | 31.2694 | Trasepunkt | S2 | Pumpeledning spillvann | 0.00767812 | 0.162434 | 0.089703 | 10.0164 | 0.901293
m-f_VA, Trase9, Overvannsledning | WxEvytnDwUqwhXPG1TxPWA==:-3015 | WxEvytnDwUqwhXPG1TxPWA==:-3948 | StormwaterPipe | Dobbeltveggede overvannsrør | OV | DVO | 12.0402 | 0.951698 | 0.0790434 | 79.0 | 27.5 | SN8 | 7 | WxEvytnDwUqwhXPG1TxPWA==:-1146 | WS_StormwaterPipeNetwork | 12.0777 | 38.5506 | 39.5023 | Trasepunkt | Trasepunkt | Overvannsledning | 0.299788 | 1.26568 | 0.0024622 | 12.041 | 3.79784

# IfcAnnotation: SURVEYSTRINGLINE_TRENCH (418)
In: SURVEY_TRENCH
PredefinedType: USERDEFINED
Name | Description | TYPEID | VIPSSURFACENO | VIPSSURFACENAME
Trase5 / -6.01 / Utility Trench Edge Surface / Line | UtilityTrenchEdgeSurfaceEdge | Utility Trench Edge Surface | -6.01 | Trase5 / -6.01 / Utility Trench Edge Surface / Line
Trase5 / -1.01 / Utility Trench Bottom / Line | UtilityTrenchBottomEdge | Utility Trench Bottom | -1.01 | Trase5 / -1.01 / Utility Trench Bottom / Line
Trase5 / -4.01 / Utility Trench Bottom / Line | UtilityTrenchBottomEdge | Utility Trench Bottom | -4.01 | Trase5 / -4.01 / Utility Trench Bottom / Line
Trase5 / 1.01 / Utility Trench Bottom / Line | UtilityTrenchBottomEdge | Utility Trench Bottom | 1.01 | Trase5 / 1.01 / Utility Trench Bottom / Line
Trase5 / Roadbed / Slope Change Bottom Left Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_LEFT_SLOPE_CHANGE_BOTTOM | Trase5 / Roadbed / Slope Change Bottom Left Line
Trase5 / 4.01 / Utility Trench Bottom / Line | UtilityTrenchBottomEdge | Utility Trench Bottom | 4.01 | Trase5 / 4.01 / Utility Trench Bottom / Line
Trase5 / 6.01 / Utility Trench Edge Surface / Line | UtilityTrenchEdgeSurfaceEdge | Utility Trench Edge Surface | 6.01 | Trase5 / 6.01 / Utility Trench Edge Surface / Line
Trase5 / Roadbed / Edge Left Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_LEFT_EDGE | Trase5 / Roadbed / Edge Left Line
Trase5 / Roadbed / Slope Change Top Left Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_LEFT_SLOPE_CHANGE_TOP | Trase5 / Roadbed / Slope Change Top Left Line
Trase5 / Protection / Edge Left Line | StakeOutStringEmbedment | Protection | TRENCH_INITIAL_BACKFILL_LEFT_EDGE | Trase5 / Protection / Edge Left Line
Trase5 / Roadbed / Edge Right Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_RIGHT_EDGE | Trase5 / Roadbed / Edge Right Line
Trase5 / Roadbed / Centre Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_CENTRELINE | Trase5 / Roadbed / Centre Line
Trase5 / Roadbed / Slope Change Bottom Right Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_RIGHT_SLOPE_CHANGE_BOTTOM | Trase5 / Roadbed / Slope Change Bottom Right Line
Trase5 / Roadbed / Slope Change Top Right Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_RIGHT_SLOPE_CHANGE_TOP | Trase5 / Roadbed / Slope Change Top Right Line
Trase5 / Protection / Edge Right Line | StakeOutStringEmbedment | Protection | TRENCH_INITIAL_BACKFILL_RIGHT_EDGE | Trase5 / Protection / Edge Right Line
Trase 1 / Foundation / Edge Left Line | StakeOutStringEmbedment | Foundation | TRENCH_LOWER_BEDDING_LEFT_EDGE | Trase 1 / Foundation / Edge Left Line
Trase 1 / Side Protection / Edge Right Line | StakeOutStringEmbedment | Side Protection | TRENCH_SIDEFILL_RIGHT_EDGE | Trase 1 / Side Protection / Edge Right Line
Trase 1 / Foundation / Edge Right Line | StakeOutStringEmbedment | Foundation | TRENCH_LOWER_BEDDING_RIGHT_EDGE | Trase 1 / Foundation / Edge Right Line
Trase 1 / Side Protection / Edge Left Line | StakeOutStringEmbedment | Side Protection | TRENCH_SIDEFILL_LEFT_EDGE | Trase 1 / Side Protection / Edge Left Line
Trase 1 / Geotextile / Edge Left Line | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_LEFT_EDGE | Trase 1 / Geotextile / Edge Left Line
Trase 1 / Geotextile / Edge Right Line | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_RIGHT_EDGE | Trase 1 / Geotextile / Edge Right Line
Trase 1 / Geotextile / Centre Line 1 | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_CENTRELINE | Trase 1 / Geotextile / Centre Line 1
Trase 1 / Geotextile / Slope Change Top Right Line | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_RIGHT_SLOPE_CHANGE_TOP | Trase 1 / Geotextile / Slope Change Top Right Line
Trase 1 / Geotextile / Slope Change Bottom Right Line | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_RIGHT_SLOPE_CHANGE_BOTTOM | Trase 1 / Geotextile / Slope Change Bottom Right Line
Trase 1 / Geotextile / Slope Change Bottom Left Line | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_LEFT_SLOPE_CHANGE_BOTTOM | Trase 1 / Geotextile / Slope Change Bottom Left Line
Trase 1 / Geotextile / Slope Change Top Left Line | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_LEFT_SLOPE_CHANGE_TOP | Trase 1 / Geotextile / Slope Change Top Left Line
Trase5 / Side Protection / Edge Right Line | StakeOutStringEmbedment | Side Protection | TRENCH_SIDEFILL_RIGHT_EDGE | Trase5 / Side Protection / Edge Right Line
Trase5 / Side Protection / Edge Left Line | StakeOutStringEmbedment | Side Protection | TRENCH_SIDEFILL_LEFT_EDGE | Trase5 / Side Protection / Edge Left Line
Trase5 / Foundation / Edge Left Line | StakeOutStringEmbedment | Foundation | TRENCH_LOWER_BEDDING_LEFT_EDGE | Trase5 / Foundation / Edge Left Line
Trase5 / Foundation / Edge Right Line | StakeOutStringEmbedment | Foundation | TRENCH_LOWER_BEDDING_RIGHT_EDGE | Trase5 / Foundation / Edge Right Line
Trase5 / Geotextile / Edge Left Line | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_LEFT_EDGE | Trase5 / Geotextile / Edge Left Line
Trase5 / Geotextile / Slope Change Top Right Line | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_RIGHT_SLOPE_CHANGE_TOP | Trase5 / Geotextile / Slope Change Top Right Line
Trase5 / Geotextile / Centre Line 1 | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_CENTRELINE | Trase5 / Geotextile / Centre Line 1
Trase5 / Geotextile / Edge Right Line | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_RIGHT_EDGE | Trase5 / Geotextile / Edge Right Line
Trase5 / Geotextile / Slope Change Top Left Line | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_LEFT_SLOPE_CHANGE_TOP | Trase5 / Geotextile / Slope Change Top Left Line
Trase5 / Geotextile / Slope Change Bottom Right Line | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_RIGHT_SLOPE_CHANGE_BOTTOM | Trase5 / Geotextile / Slope Change Bottom Right Line
Trase5 / Geotextile / Slope Change Bottom Left Line | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_LEFT_SLOPE_CHANGE_BOTTOM | Trase5 / Geotextile / Slope Change Bottom Left Line
Trase5 / SubgradeSurface Outside Pavement / Slope Change Bottom Left Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_LEFT_SLOPE_CHANGE_BOTTOM | Trase5 / SubgradeSurface Outside Pavement / Slope Change Bottom Left Line
Trase5 / Geotextile / Centre Line 2 | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_CENTRELINE | Trase5 / Geotextile / Centre Line 2
Trase5 / SubgradeSurface Outside Pavement / Edge Left Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_LEFT_EDGE | Trase5 / SubgradeSurface Outside Pavement / Edge Left Line
Trase5 / SubgradeSurface Outside Pavement / Centre Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_CENTRELINE | Trase5 / SubgradeSurface Outside Pavement / Centre Line
Trase5 / SubgradeSurface Outside Pavement / Slope Change Top Left Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_LEFT_SLOPE_CHANGE_TOP | Trase5 / SubgradeSurface Outside Pavement / Slope Change Top Left Line
Trase5 / SubgradeSurface Outside Pavement / Slope Change Bottom Right Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_RIGHT_SLOPE_CHANGE_BOTTOM | Trase5 / SubgradeSurface Outside Pavement / Slope Change Bottom Right Line
Trase5 / SubgradeSurface Outside Pavement / Slope Change Top Right Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_RIGHT_SLOPE_CHANGE_TOP | Trase5 / SubgradeSurface Outside Pavement / Slope Change Top Right Line
Trase5 / SubgradeSurface Outside Pavement / Edge Right Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_RIGHT_EDGE | Trase5 / SubgradeSurface Outside Pavement / Edge Right Line
Trase4 / -6.01 / Utility Trench Edge Surface / Line | UtilityTrenchEdgeSurfaceEdge | Utility Trench Edge Surface | -6.01 | Trase4 / -6.01 / Utility Trench Edge Surface / Line
Trase4 / -4.01 / Utility Trench Bottom / Line | UtilityTrenchBottomEdge | Utility Trench Bottom | -4.01 | Trase4 / -4.01 / Utility Trench Bottom / Line
Trase4 / -1.01 / Utility Trench Bottom / Line | UtilityTrenchBottomEdge | Utility Trench Bottom | -1.01 | Trase4 / -1.01 / Utility Trench Bottom / Line
Trase4 / 1.01 / Utility Trench Bottom / Line | UtilityTrenchBottomEdge | Utility Trench Bottom | 1.01 | Trase4 / 1.01 / Utility Trench Bottom / Line
Trase4 / Roadbed / Slope Change Bottom Left Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_LEFT_SLOPE_CHANGE_BOTTOM | Trase4 / Roadbed / Slope Change Bottom Left Line
Trase4 / Roadbed / Edge Left Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_LEFT_EDGE | Trase4 / Roadbed / Edge Left Line
Trase4 / 6.01 / Utility Trench Edge Surface / Line | UtilityTrenchEdgeSurfaceEdge | Utility Trench Edge Surface | 6.01 | Trase4 / 6.01 / Utility Trench Edge Surface / Line
Trase4 / 4.01 / Utility Trench Bottom / Line | UtilityTrenchBottomEdge | Utility Trench Bottom | 4.01 | Trase4 / 4.01 / Utility Trench Bottom / Line
Trase4 / Roadbed / Slope Change Top Left Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_LEFT_SLOPE_CHANGE_TOP | Trase4 / Roadbed / Slope Change Top Left Line
Trase4 / Roadbed / Slope Change Top Right Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_RIGHT_SLOPE_CHANGE_TOP | Trase4 / Roadbed / Slope Change Top Right Line
Trase4 / Roadbed / Slope Change Bottom Right Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_RIGHT_SLOPE_CHANGE_BOTTOM | Trase4 / Roadbed / Slope Change Bottom Right Line
Trase4 / Roadbed / Centre Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_CENTRELINE | Trase4 / Roadbed / Centre Line
Trase4 / Roadbed / Edge Right Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_RIGHT_EDGE | Trase4 / Roadbed / Edge Right Line
Trase4 / Protection / Edge Left Line | StakeOutStringEmbedment | Protection | TRENCH_INITIAL_BACKFILL_LEFT_EDGE | Trase4 / Protection / Edge Left Line
Trase4 / Foundation / Edge Right Line | StakeOutStringEmbedment | Foundation | TRENCH_LOWER_BEDDING_RIGHT_EDGE | Trase4 / Foundation / Edge Right Line
Trase4 / Foundation / Edge Left Line | StakeOutStringEmbedment | Foundation | TRENCH_LOWER_BEDDING_LEFT_EDGE | Trase4 / Foundation / Edge Left Line
Trase4 / Protection / Edge Right Line | StakeOutStringEmbedment | Protection | TRENCH_INITIAL_BACKFILL_RIGHT_EDGE | Trase4 / Protection / Edge Right Line
Trase4 / Side Protection / Edge Right Line | StakeOutStringEmbedment | Side Protection | TRENCH_SIDEFILL_RIGHT_EDGE | Trase4 / Side Protection / Edge Right Line
Trase4 / Side Protection / Edge Left Line | StakeOutStringEmbedment | Side Protection | TRENCH_SIDEFILL_LEFT_EDGE | Trase4 / Side Protection / Edge Left Line
Trase4 / Geotextile / Slope Change Top Left Line | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_LEFT_SLOPE_CHANGE_TOP | Trase4 / Geotextile / Slope Change Top Left Line
Trase4 / Geotextile / Centre Line 1 | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_CENTRELINE | Trase4 / Geotextile / Centre Line 1
Trase4 / Geotextile / Slope Change Bottom Left Line | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_LEFT_SLOPE_CHANGE_BOTTOM | Trase4 / Geotextile / Slope Change Bottom Left Line
Trase4 / Geotextile / Slope Change Top Right Line | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_RIGHT_SLOPE_CHANGE_TOP | Trase4 / Geotextile / Slope Change Top Right Line
Trase4 / Geotextile / Edge Left Line | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_LEFT_EDGE | Trase4 / Geotextile / Edge Left Line
Trase4 / Geotextile / Slope Change Bottom Right Line | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_RIGHT_SLOPE_CHANGE_BOTTOM | Trase4 / Geotextile / Slope Change Bottom Right Line
Trase4 / SubgradeSurface Outside Pavement / Slope Change Bottom Left Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_LEFT_SLOPE_CHANGE_BOTTOM | Trase4 / SubgradeSurface Outside Pavement / Slope Change Bottom Left Line
Trase4 / Geotextile / Edge Right Line | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_RIGHT_EDGE | Trase4 / Geotextile / Edge Right Line
Trase4 / SubgradeSurface Outside Pavement / Edge Left Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_LEFT_EDGE | Trase4 / SubgradeSurface Outside Pavement / Edge Left Line
Trase4 / Geotextile / Centre Line 2 | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_CENTRELINE | Trase4 / Geotextile / Centre Line 2
Trase4 / SubgradeSurface Outside Pavement / Slope Change Top Left Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_LEFT_SLOPE_CHANGE_TOP | Trase4 / SubgradeSurface Outside Pavement / Slope Change Top Left Line
Trase4 / SubgradeSurface Outside Pavement / Slope Change Bottom Right Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_RIGHT_SLOPE_CHANGE_BOTTOM | Trase4 / SubgradeSurface Outside Pavement / Slope Change Bottom Right Line
Trase4 / SubgradeSurface Outside Pavement / Edge Right Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_RIGHT_EDGE | Trase4 / SubgradeSurface Outside Pavement / Edge Right Line
Trase4 / SubgradeSurface Outside Pavement / Centre Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_CENTRELINE | Trase4 / SubgradeSurface Outside Pavement / Centre Line
Trase4 / SubgradeSurface Outside Pavement / Slope Change Top Right Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_RIGHT_SLOPE_CHANGE_TOP | Trase4 / SubgradeSurface Outside Pavement / Slope Change Top Right Line
Trase 1 / Geotextile / Centre Line 2 | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_CENTRELINE | Trase 1 / Geotextile / Centre Line 2
Trase 1 / -4.01 / Utility Trench Bottom / Line | UtilityTrenchBottomEdge | Utility Trench Bottom | -4.01 | Trase 1 / -4.01 / Utility Trench Bottom / Line
Trase 1 / -6.01 / Utility Trench Edge Surface / Line | UtilityTrenchEdgeSurfaceEdge | Utility Trench Edge Surface | -6.01 | Trase 1 / -6.01 / Utility Trench Edge Surface / Line
Trase 1 / -1.01 / Utility Trench Bottom / Line | UtilityTrenchBottomEdge | Utility Trench Bottom | -1.01 | Trase 1 / -1.01 / Utility Trench Bottom / Line
Trase 1 / 1.01 / Utility Trench Bottom / Line | UtilityTrenchBottomEdge | Utility Trench Bottom | 1.01 | Trase 1 / 1.01 / Utility Trench Bottom / Line
Trase 1 / Roadbed / Slope Change Top Left Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_LEFT_SLOPE_CHANGE_TOP | Trase 1 / Roadbed / Slope Change Top Left Line
Trase 1 / Roadbed / Centre Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_CENTRELINE | Trase 1 / Roadbed / Centre Line
Trase 1 / 6.01 / Utility Trench Edge Surface / Line | UtilityTrenchEdgeSurfaceEdge | Utility Trench Edge Surface | 6.01 | Trase 1 / 6.01 / Utility Trench Edge Surface / Line
Trase 1 / Roadbed / Edge Left Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_LEFT_EDGE | Trase 1 / Roadbed / Edge Left Line
Trase 1 / Roadbed / Slope Change Bottom Left Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_LEFT_SLOPE_CHANGE_BOTTOM | Trase 1 / Roadbed / Slope Change Bottom Left Line
Trase 1 / 4.01 / Utility Trench Bottom / Line | UtilityTrenchBottomEdge | Utility Trench Bottom | 4.01 | Trase 1 / 4.01 / Utility Trench Bottom / Line
Trase 1 / Roadbed / Slope Change Bottom Right Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_RIGHT_SLOPE_CHANGE_BOTTOM | Trase 1 / Roadbed / Slope Change Bottom Right Line
Trase 1 / Roadbed / Slope Change Top Right Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_RIGHT_SLOPE_CHANGE_TOP | Trase 1 / Roadbed / Slope Change Top Right Line
Trase 1 / Protection / Edge Left Line | StakeOutStringEmbedment | Protection | TRENCH_INITIAL_BACKFILL_LEFT_EDGE | Trase 1 / Protection / Edge Left Line
Trase 1 / Protection / Edge Right Line | StakeOutStringEmbedment | Protection | TRENCH_INITIAL_BACKFILL_RIGHT_EDGE | Trase 1 / Protection / Edge Right Line
Trase 1 / Roadbed / Edge Right Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_RIGHT_EDGE | Trase 1 / Roadbed / Edge Right Line
Trase6 / -6.01 / Utility Trench Edge Surface / Line | UtilityTrenchEdgeSurfaceEdge | Utility Trench Edge Surface | -6.01 | Trase6 / -6.01 / Utility Trench Edge Surface / Line
Trase6 / -4.01 / Utility Trench Bottom / Line | UtilityTrenchBottomEdge | Utility Trench Bottom | -4.01 | Trase6 / -4.01 / Utility Trench Bottom / Line
Trase6 / Protection / Slope Change Bottom Left Line | StakeOutStringEmbedment | Protection | TRENCH_INITIAL_BACKFILL_LEFT_SLOPE_CHANGE_BOTTOM | Trase6 / Protection / Slope Change Bottom Left Line
Trase6 / 4.01 / Utility Trench Bottom / Line | UtilityTrenchBottomEdge | Utility Trench Bottom | 4.01 | Trase6 / 4.01 / Utility Trench Bottom / Line
Trase6 / Protection / Slope Change Top Left Line | StakeOutStringEmbedment | Protection | TRENCH_INITIAL_BACKFILL_LEFT_SLOPE_CHANGE_TOP | Trase6 / Protection / Slope Change Top Left Line
Trase6 / Roadbed / Slope Change Bottom Left Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_LEFT_SLOPE_CHANGE_BOTTOM | Trase6 / Roadbed / Slope Change Bottom Left Line
Trase6 / SubgradeSurface Outside Pavement / Slope Change Bottom Left Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_LEFT_SLOPE_CHANGE_BOTTOM | Trase6 / SubgradeSurface Outside Pavement / Slope Change Bottom Left Line
Trase6 / SubgradeSurface Outside Pavement / Slope Change Bottom Right Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_RIGHT_SLOPE_CHANGE_BOTTOM | Trase6 / SubgradeSurface Outside Pavement / Slope Change Bottom Right Line
Trase6 / 6.01 / Utility Trench Edge Surface / Line | UtilityTrenchEdgeSurfaceEdge | Utility Trench Edge Surface | 6.01 | Trase6 / 6.01 / Utility Trench Edge Surface / Line
Trase6 / Roadbed / Slope Change Bottom Right Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_RIGHT_SLOPE_CHANGE_BOTTOM | Trase6 / Roadbed / Slope Change Bottom Right Line
Trase6 / -1.01 / Utility Trench Bottom / Line | UtilityTrenchBottomEdge | Utility Trench Bottom | -1.01 | Trase6 / -1.01 / Utility Trench Bottom / Line
Trase 1 / SubgradeSurface Outside Pavement / Edge Left Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_LEFT_EDGE | Trase 1 / SubgradeSurface Outside Pavement / Edge Left Line
Trase 1 / SubgradeSurface Outside Pavement / Centre Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_CENTRELINE | Trase 1 / SubgradeSurface Outside Pavement / Centre Line
Trase 1 / SubgradeSurface Outside Pavement / Slope Change Top Right Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_RIGHT_SLOPE_CHANGE_TOP | Trase 1 / SubgradeSurface Outside Pavement / Slope Change Top Right Line
Trase 1 / SubgradeSurface Outside Pavement / Slope Change Bottom Right Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_RIGHT_SLOPE_CHANGE_BOTTOM | Trase 1 / SubgradeSurface Outside Pavement / Slope Change Bottom Right Line
Trase 1 / SubgradeSurface Outside Pavement / Slope Change Top Left Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_LEFT_SLOPE_CHANGE_TOP | Trase 1 / SubgradeSurface Outside Pavement / Slope Change Top Left Line
Trase 1 / SubgradeSurface Outside Pavement / Slope Change Bottom Left Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_LEFT_SLOPE_CHANGE_BOTTOM | Trase 1 / SubgradeSurface Outside Pavement / Slope Change Bottom Left Line
Trase 1 / SubgradeSurface Outside Pavement / Edge Right Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_RIGHT_EDGE | Trase 1 / SubgradeSurface Outside Pavement / Edge Right Line
Trase 2 / -4.01 / Utility Trench Bottom / Line | UtilityTrenchBottomEdge | Utility Trench Bottom | -4.01 | Trase 2 / -4.01 / Utility Trench Bottom / Line
Trase 2 / -1.01 / Utility Trench Bottom / Line | UtilityTrenchBottomEdge | Utility Trench Bottom | -1.01 | Trase 2 / -1.01 / Utility Trench Bottom / Line
Trase 2 / -6.01 / Utility Trench Edge Surface / Line | UtilityTrenchEdgeSurfaceEdge | Utility Trench Edge Surface | -6.01 | Trase 2 / -6.01 / Utility Trench Edge Surface / Line
Trase 2 / 6.01 / Utility Trench Edge Surface / Line | UtilityTrenchEdgeSurfaceEdge | Utility Trench Edge Surface | 6.01 | Trase 2 / 6.01 / Utility Trench Edge Surface / Line
Trase 2 / 1.01 / Utility Trench Bottom / Line | UtilityTrenchBottomEdge | Utility Trench Bottom | 1.01 | Trase 2 / 1.01 / Utility Trench Bottom / Line
Trase 2 / 4.01 / Utility Trench Bottom / Line | UtilityTrenchBottomEdge | Utility Trench Bottom | 4.01 | Trase 2 / 4.01 / Utility Trench Bottom / Line
Trase 2 / Roadbed / Edge Left Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_LEFT_EDGE | Trase 2 / Roadbed / Edge Left Line
Trase 2 / Roadbed / Edge Right Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_RIGHT_EDGE | Trase 2 / Roadbed / Edge Right Line
Trase 2 / Roadbed / Slope Change Bottom Left Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_LEFT_SLOPE_CHANGE_BOTTOM | Trase 2 / Roadbed / Slope Change Bottom Left Line
Trase 2 / Roadbed / Slope Change Top Right Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_RIGHT_SLOPE_CHANGE_TOP | Trase 2 / Roadbed / Slope Change Top Right Line
Trase 2 / Roadbed / Slope Change Bottom Right Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_RIGHT_SLOPE_CHANGE_BOTTOM | Trase 2 / Roadbed / Slope Change Bottom Right Line
Trase 2 / Roadbed / Slope Change Top Left Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_LEFT_SLOPE_CHANGE_TOP | Trase 2 / Roadbed / Slope Change Top Left Line
Trase 2 / Roadbed / Centre Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_CENTRELINE | Trase 2 / Roadbed / Centre Line
Trase 2 / Side Protection / Edge Left Line | StakeOutStringEmbedment | Side Protection | TRENCH_SIDEFILL_LEFT_EDGE | Trase 2 / Side Protection / Edge Left Line
Trase 2 / Foundation / Edge Left Line | StakeOutStringEmbedment | Foundation | TRENCH_LOWER_BEDDING_LEFT_EDGE | Trase 2 / Foundation / Edge Left Line
2 x Trase 2 / Protection / Slope Change Top Left Line | StakeOutStringEmbedment | Protection | TRENCH_INITIAL_BACKFILL_LEFT_SLOPE_CHANGE_TOP | Trase 2 / Protection / Slope Change Top Left Line
Trase 2 / Foundation / Edge Right Line | StakeOutStringEmbedment | Foundation | TRENCH_LOWER_BEDDING_RIGHT_EDGE | Trase 2 / Foundation / Edge Right Line
Trase 2 / Protection / Edge Right Line | StakeOutStringEmbedment | Protection | TRENCH_INITIAL_BACKFILL_RIGHT_EDGE | Trase 2 / Protection / Edge Right Line
Trase 2 / SubgradeSurface Outside Pavement / Edge Left Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_LEFT_EDGE | Trase 2 / SubgradeSurface Outside Pavement / Edge Left Line
Trase 2 / Side Protection / Edge Right Line | StakeOutStringEmbedment | Side Protection | TRENCH_SIDEFILL_RIGHT_EDGE | Trase 2 / Side Protection / Edge Right Line
Trase 2 / Geotextile / Centre Line 2 | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_CENTRELINE | Trase 2 / Geotextile / Centre Line 2
