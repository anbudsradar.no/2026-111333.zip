Properties of the parts of a building model (IFC4X3_ADD2), part 2 of 3

# IfcAnnotation: SURVEYSTRINGLINE_TRENCH (418)
Name | Description | TYPEID | VIPSSURFACENO | VIPSSURFACENAME
Trase 2 / Geotextile / Centre Line 1 | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_CENTRELINE | Trase 2 / Geotextile / Centre Line 1
Trase 2 / Geotextile / Slope Change Top Left Line | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_LEFT_SLOPE_CHANGE_TOP | Trase 2 / Geotextile / Slope Change Top Left Line
Trase 2 / Geotextile / Slope Change Bottom Right Line | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_RIGHT_SLOPE_CHANGE_BOTTOM | Trase 2 / Geotextile / Slope Change Bottom Right Line
Trase 2 / SubgradeSurface Outside Pavement / Edge Right Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_RIGHT_EDGE | Trase 2 / SubgradeSurface Outside Pavement / Edge Right Line
Trase 2 / SubgradeSurface Outside Pavement / Slope Change Top Right Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_RIGHT_SLOPE_CHANGE_TOP | Trase 2 / SubgradeSurface Outside Pavement / Slope Change Top Right Line
Trase 2 / SubgradeSurface Outside Pavement / Slope Change Top Left Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_LEFT_SLOPE_CHANGE_TOP | Trase 2 / SubgradeSurface Outside Pavement / Slope Change Top Left Line
Trase 2 / SubgradeSurface Outside Pavement / Slope Change Bottom Left Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_LEFT_SLOPE_CHANGE_BOTTOM | Trase 2 / SubgradeSurface Outside Pavement / Slope Change Bottom Left Line
Trase 2 / SubgradeSurface Outside Pavement / Centre Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_CENTRELINE | Trase 2 / SubgradeSurface Outside Pavement / Centre Line
Trase 2 / SubgradeSurface Outside Pavement / Slope Change Bottom Right Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_RIGHT_SLOPE_CHANGE_BOTTOM | Trase 2 / SubgradeSurface Outside Pavement / Slope Change Bottom Right Line
Trase 2 / Geotextile / Slope Change Top Right Line | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_RIGHT_SLOPE_CHANGE_TOP | Trase 2 / Geotextile / Slope Change Top Right Line
Trase6 / Roadbed / Slope Change Top Right Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_RIGHT_SLOPE_CHANGE_TOP | Trase6 / Roadbed / Slope Change Top Right Line
Trase6 / Roadbed / Slope Change Top Left Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_LEFT_SLOPE_CHANGE_TOP | Trase6 / Roadbed / Slope Change Top Left Line
Trase6 / Roadbed / Centre Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_CENTRELINE | Trase6 / Roadbed / Centre Line
Trase6 / Roadbed / Edge Left Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_LEFT_EDGE | Trase6 / Roadbed / Edge Left Line
Trase6 / 1.01 / Utility Trench Bottom / Line | UtilityTrenchBottomEdge | Utility Trench Bottom | 1.01 | Trase6 / 1.01 / Utility Trench Bottom / Line
Trase6 / Roadbed / Edge Right Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_RIGHT_EDGE | Trase6 / Roadbed / Edge Right Line
Trase6 / Protection / Edge Left Line | StakeOutStringEmbedment | Protection | TRENCH_INITIAL_BACKFILL_LEFT_EDGE | Trase6 / Protection / Edge Left Line
Trase6 / Protection / Edge Right Line | StakeOutStringEmbedment | Protection | TRENCH_INITIAL_BACKFILL_RIGHT_EDGE | Trase6 / Protection / Edge Right Line
Trase6 / Foundation / Edge Left Line | StakeOutStringEmbedment | Foundation | TRENCH_LOWER_BEDDING_LEFT_EDGE | Trase6 / Foundation / Edge Left Line
Trase6 / Foundation / Slope Change Top Right Line | StakeOutStringEmbedment | Foundation | TRENCH_LOWER_BEDDING_RIGHT_SLOPE_CHANGE_TOP | Trase6 / Foundation / Slope Change Top Right Line
Trase6 / Geotextile / Slope Change Bottom Left Line | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_LEFT_SLOPE_CHANGE_BOTTOM | Trase6 / Geotextile / Slope Change Bottom Left Line
Trase6 / Geotextile / Centre Line 1 | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_CENTRELINE | Trase6 / Geotextile / Centre Line 1
Trase6 / Side Protection / Edge Right Line | StakeOutStringEmbedment | Side Protection | TRENCH_SIDEFILL_RIGHT_EDGE | Trase6 / Side Protection / Edge Right Line
Trase6 / Geotextile / Edge Left Line | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_LEFT_EDGE | Trase6 / Geotextile / Edge Left Line
Trase6 / Geotextile / Slope Change Top Left Line | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_LEFT_SLOPE_CHANGE_TOP | Trase6 / Geotextile / Slope Change Top Left Line
Trase6 / Side Protection / Slope Change Top Left Line | StakeOutStringEmbedment | Side Protection | TRENCH_SIDEFILL_LEFT_SLOPE_CHANGE_TOP | Trase6 / Side Protection / Slope Change Top Left Line
Trase6 / Geotextile / Slope Change Bottom Right Line | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_RIGHT_SLOPE_CHANGE_BOTTOM | Trase6 / Geotextile / Slope Change Bottom Right Line
Trase6 / Geotextile / Slope Change Top Right Line | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_RIGHT_SLOPE_CHANGE_TOP | Trase6 / Geotextile / Slope Change Top Right Line
Trase6 / Geotextile / Centre Line 2 | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_CENTRELINE | Trase6 / Geotextile / Centre Line 2
Trase6 / SubgradeSurface Outside Pavement / Edge Left Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_LEFT_EDGE | Trase6 / SubgradeSurface Outside Pavement / Edge Left Line
Trase6 / Geotextile / Edge Right Line | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_RIGHT_EDGE | Trase6 / Geotextile / Edge Right Line
Trase6 / 7.01 / Utility Trench Edge Surface / Line | UtilityTrenchEdgeSurfaceEdge | Utility Trench Edge Surface | 7.01 | Trase6 / 7.01 / Utility Trench Edge Surface / Line
Trase6 / -7.01 / Utility Trench Edge Surface / Line | UtilityTrenchEdgeSurfaceEdge | Utility Trench Edge Surface | -7.01 | Trase6 / -7.01 / Utility Trench Edge Surface / Line
Trase6 / SubgradeSurface Outside Pavement / Slope Change Top Left Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_LEFT_SLOPE_CHANGE_TOP | Trase6 / SubgradeSurface Outside Pavement / Slope Change Top Left Line
Trase6 / SubgradeSurface Outside Pavement / Centre Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_CENTRELINE | Trase6 / SubgradeSurface Outside Pavement / Centre Line
Trase6 / SubgradeSurface Outside Pavement / Slope Change Top Right Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_RIGHT_SLOPE_CHANGE_TOP | Trase6 / SubgradeSurface Outside Pavement / Slope Change Top Right Line
Trase6 / SubgradeSurface Outside Pavement / Edge Right Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_RIGHT_EDGE | Trase6 / SubgradeSurface Outside Pavement / Edge Right Line
2 x Trase7 / -6.01 / Utility Trench Edge Surface / Line | UtilityTrenchEdgeSurfaceEdge | Utility Trench Edge Surface | -6.01 | Trase7 / -6.01 / Utility Trench Edge Surface / Line
Trase7 / -1.01 / Utility Trench Bottom / Line | UtilityTrenchBottomEdge | Utility Trench Bottom | -1.01 | Trase7 / -1.01 / Utility Trench Bottom / Line
Trase7 / 1.01 / Utility Trench Bottom / Line | UtilityTrenchBottomEdge | Utility Trench Bottom | 1.01 | Trase7 / 1.01 / Utility Trench Bottom / Line
2 x Trase7 / -4.01 / Utility Trench Bottom / Line | UtilityTrenchBottomEdge | Utility Trench Bottom | -4.01 | Trase7 / -4.01 / Utility Trench Bottom / Line
Trase7 / 4.01 / Utility Trench Bottom / Line | UtilityTrenchBottomEdge | Utility Trench Bottom | 4.01 | Trase7 / 4.01 / Utility Trench Bottom / Line
Trase7 / Roadbed / Centre Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_CENTRELINE | Trase7 / Roadbed / Centre Line
Trase7 / Roadbed / Slope Change Top Left Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_LEFT_SLOPE_CHANGE_TOP | Trase7 / Roadbed / Slope Change Top Left Line
2 x Trase7 / Roadbed / Slope Change Bottom Left Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_LEFT_SLOPE_CHANGE_BOTTOM | Trase7 / Roadbed / Slope Change Bottom Left Line
Trase7 / Roadbed / Edge Left Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_LEFT_EDGE | Trase7 / Roadbed / Edge Left Line
Trase7 / 6.01 / Utility Trench Edge Surface / Line | UtilityTrenchEdgeSurfaceEdge | Utility Trench Edge Surface | 6.01 | Trase7 / 6.01 / Utility Trench Edge Surface / Line
Trase7 / Roadbed / Slope Change Top Right Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_RIGHT_SLOPE_CHANGE_TOP | Trase7 / Roadbed / Slope Change Top Right Line
2 x Trase7 / Roadbed / Slope Change Bottom Right Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_RIGHT_SLOPE_CHANGE_BOTTOM | Trase7 / Roadbed / Slope Change Bottom Right Line
2 x Trase7 / Protection / Edge Right Line 1 | StakeOutStringEmbedment | Protection | TRENCH_INITIAL_BACKFILL_RIGHT_EDGE | Trase7 / Protection / Edge Right Line 1
Trase7 / Foundation / Edge Left Line | StakeOutStringEmbedment | Foundation | TRENCH_LOWER_BEDDING_LEFT_EDGE | Trase7 / Foundation / Edge Left Line
Trase7 / Roadbed / Edge Right Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_RIGHT_EDGE | Trase7 / Roadbed / Edge Right Line
Trase7 / Protection / Edge Left Line | StakeOutStringEmbedment | Protection | TRENCH_INITIAL_BACKFILL_LEFT_EDGE | Trase7 / Protection / Edge Left Line
Trase7 / Geotextile / Centre Line 2 | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_CENTRELINE | Trase7 / Geotextile / Centre Line 2
Trase7 / Geotextile / Slope Change Top Left Line | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_LEFT_SLOPE_CHANGE_TOP | Trase7 / Geotextile / Slope Change Top Left Line
Trase7 / Side Protection / Edge Left Line | StakeOutStringEmbedment | Side Protection | TRENCH_SIDEFILL_LEFT_EDGE | Trase7 / Side Protection / Edge Left Line
2 x Trase7 / Side Protection / Edge Right Line 1 | StakeOutStringEmbedment | Side Protection | TRENCH_SIDEFILL_RIGHT_EDGE | Trase7 / Side Protection / Edge Right Line 1
2 x Trase7 / Foundation / Edge Right Line 1 | StakeOutStringEmbedment | Foundation | TRENCH_LOWER_BEDDING_RIGHT_EDGE | Trase7 / Foundation / Edge Right Line 1
Trase7 / SubgradeSurface Outside Pavement / Edge Left Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_LEFT_EDGE | Trase7 / SubgradeSurface Outside Pavement / Edge Left Line
Trase7 / Geotextile / Slope Change Top Right Line | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_RIGHT_SLOPE_CHANGE_TOP | Trase7 / Geotextile / Slope Change Top Right Line
2 x Trase7 / SubgradeSurface Outside Pavement / Slope Change Bottom Left Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_LEFT_SLOPE_CHANGE_BOTTOM | Trase7 / SubgradeSurface Outside Pavement / Slope Change Bottom Left Line
Trase7 / SubgradeSurface Outside Pavement / Slope Change Top Left Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_LEFT_SLOPE_CHANGE_TOP | Trase7 / SubgradeSurface Outside Pavement / Slope Change Top Left Line
Trase7 / SubgradeSurface Outside Pavement / Centre Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_CENTRELINE | Trase7 / SubgradeSurface Outside Pavement / Centre Line
Trase7 / Geotextile / Centre Line 1 | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_CENTRELINE | Trase7 / Geotextile / Centre Line 1
2 x Trase7 / SubgradeSurface Outside Pavement / Slope Change Bottom Right Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_RIGHT_SLOPE_CHANGE_BOTTOM | Trase7 / SubgradeSurface Outside Pavement / Slope Change Bottom Right Line
Trase7 / Protection / Slope Change Top Left Line | StakeOutStringEmbedment | Protection | TRENCH_INITIAL_BACKFILL_LEFT_SLOPE_CHANGE_TOP | Trase7 / Protection / Slope Change Top Left Line
Trase7 / SubgradeSurface Outside Pavement / Edge Right Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_RIGHT_EDGE | Trase7 / SubgradeSurface Outside Pavement / Edge Right Line
Trase7 / SubgradeSurface Outside Pavement / Slope Change Top Right Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_RIGHT_SLOPE_CHANGE_TOP | Trase7 / SubgradeSurface Outside Pavement / Slope Change Top Right Line
Trase7 / Foundation / Slope Change Top Left Line | StakeOutStringEmbedment | Foundation | TRENCH_LOWER_BEDDING_LEFT_SLOPE_CHANGE_TOP | Trase7 / Foundation / Slope Change Top Left Line
Trase7 / Side Protection / Slope Change Top Left Line | StakeOutStringEmbedment | Side Protection | TRENCH_SIDEFILL_LEFT_SLOPE_CHANGE_TOP | Trase7 / Side Protection / Slope Change Top Left Line
2 x Trase7 / Geotextile / Edge Right Line 2 | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_RIGHT_EDGE | Trase7 / Geotextile / Edge Right Line 2
Trase7 / Protection / Edge Right Line 2 | StakeOutStringEmbedment | Protection | TRENCH_INITIAL_BACKFILL_RIGHT_EDGE | Trase7 / Protection / Edge Right Line 2
Trase7 / -7.01 / Utility Trench Edge Surface / Line | UtilityTrenchEdgeSurfaceEdge | Utility Trench Edge Surface | -7.01 | Trase7 / -7.01 / Utility Trench Edge Surface / Line
Trase7 / Side Protection / Slope Change Bottom Right Line | StakeOutStringEmbedment | Side Protection | TRENCH_SIDEFILL_RIGHT_SLOPE_CHANGE_BOTTOM | Trase7 / Side Protection / Slope Change Bottom Right Line
Trase7 / Protection / Slope Change Bottom Right Line | StakeOutStringEmbedment | Protection | TRENCH_INITIAL_BACKFILL_RIGHT_SLOPE_CHANGE_BOTTOM | Trase7 / Protection / Slope Change Bottom Right Line
Trase7 / Foundation / Slope Change Bottom Right Line | StakeOutStringEmbedment | Foundation | TRENCH_LOWER_BEDDING_RIGHT_SLOPE_CHANGE_BOTTOM | Trase7 / Foundation / Slope Change Bottom Right Line
Trase7 / 7.01 / Utility Trench Edge Surface / Line | UtilityTrenchEdgeSurfaceEdge | Utility Trench Edge Surface | 7.01 | Trase7 / 7.01 / Utility Trench Edge Surface / Line
Trase7 / Side Protection / Edge Right Line 2 | StakeOutStringEmbedment | Side Protection | TRENCH_SIDEFILL_RIGHT_EDGE | Trase7 / Side Protection / Edge Right Line 2
Trase7 / Geotextile / Slope Change Bottom Left Line 1 | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_LEFT_SLOPE_CHANGE_BOTTOM | Trase7 / Geotextile / Slope Change Bottom Left Line 1
Trase7 / Foundation / Edge Right Line 2 | StakeOutStringEmbedment | Foundation | TRENCH_LOWER_BEDDING_RIGHT_EDGE | Trase7 / Foundation / Edge Right Line 2
Trase7 / Protection / Slope Change Top Right Line 1 | StakeOutStringEmbedment | Protection | TRENCH_INITIAL_BACKFILL_RIGHT_SLOPE_CHANGE_TOP | Trase7 / Protection / Slope Change Top Right Line 1
Trase7 / Geotextile / Edge Left Line | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_LEFT_EDGE | Trase7 / Geotextile / Edge Left Line
Trase7 / Foundation / Slope Change Top Right Line 1 | StakeOutStringEmbedment | Foundation | TRENCH_LOWER_BEDDING_RIGHT_SLOPE_CHANGE_TOP | Trase7 / Foundation / Slope Change Top Right Line 1
Trase7 / Side Protection / Slope Change Top Right Line 1 | StakeOutStringEmbedment | Side Protection | TRENCH_SIDEFILL_RIGHT_SLOPE_CHANGE_TOP | Trase7 / Side Protection / Slope Change Top Right Line 1
Trase7 / Geotextile / Slope Change Bottom Left Line 2 | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_LEFT_SLOPE_CHANGE_BOTTOM | Trase7 / Geotextile / Slope Change Bottom Left Line 2
Trase7 / Foundation / Slope Change Top Right Line 2 | StakeOutStringEmbedment | Foundation | TRENCH_LOWER_BEDDING_RIGHT_SLOPE_CHANGE_TOP | Trase7 / Foundation / Slope Change Top Right Line 2
Trase7 / Side Protection / Slope Change Top Right Line 2 | StakeOutStringEmbedment | Side Protection | TRENCH_SIDEFILL_RIGHT_SLOPE_CHANGE_TOP | Trase7 / Side Protection / Slope Change Top Right Line 2
Trase7 / Protection / Slope Change Top Right Line 2 | StakeOutStringEmbedment | Protection | TRENCH_INITIAL_BACKFILL_RIGHT_SLOPE_CHANGE_TOP | Trase7 / Protection / Slope Change Top Right Line 2
Trase6 / Foundation / Edge Right Line | StakeOutStringEmbedment | Foundation | TRENCH_LOWER_BEDDING_RIGHT_EDGE | Trase6 / Foundation / Edge Right Line
Trase6 / Side Protection / Edge Left Line | StakeOutStringEmbedment | Side Protection | TRENCH_SIDEFILL_LEFT_EDGE | Trase6 / Side Protection / Edge Left Line
Trase7 / Geotextile / Edge Right Line 1 | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_RIGHT_EDGE | Trase7 / Geotextile / Edge Right Line 1
Trase7 / Geotextile / Slope Change Bottom Right Line | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_RIGHT_SLOPE_CHANGE_BOTTOM | Trase7 / Geotextile / Slope Change Bottom Right Line
Trase 3 / Roadbed / Edge Left Line 2 | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_LEFT_EDGE | Trase 3 / Roadbed / Edge Left Line 2
Trase 3 / SubgradeSurface Outside Pavement / Edge Left Line 2 | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_LEFT_EDGE | Trase 3 / SubgradeSurface Outside Pavement / Edge Left Line 2
3 x Trase 3 / -6.01 / Utility Trench Edge Surface / Line | UtilityTrenchEdgeSurfaceEdge | Utility Trench Edge Surface | -6.01 | Trase 3 / -6.01 / Utility Trench Edge Surface / Line
2 x Trase 3 / Protection / Edge Right Line | StakeOutStringEmbedment | Protection | TRENCH_INITIAL_BACKFILL_RIGHT_EDGE | Trase 3 / Protection / Edge Right Line
Trase 2 / Protection / Slope Change Top Right Line | StakeOutStringEmbedment | Protection | TRENCH_INITIAL_BACKFILL_RIGHT_SLOPE_CHANGE_TOP | Trase 2 / Protection / Slope Change Top Right Line
Trase 2 / Protection / Edge Left Line | StakeOutStringEmbedment | Protection | TRENCH_INITIAL_BACKFILL_LEFT_EDGE | Trase 2 / Protection / Edge Left Line
Trase 2 / Geotextile / Edge Left Line | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_LEFT_EDGE | Trase 2 / Geotextile / Edge Left Line
Trase 2 / -7.01 / Utility Trench Edge Surface / Line | UtilityTrenchEdgeSurfaceEdge | Utility Trench Edge Surface | -7.01 | Trase 2 / -7.01 / Utility Trench Edge Surface / Line
Trase 2 / 7.01 / Utility Trench Edge Surface / Line | UtilityTrenchEdgeSurfaceEdge | Utility Trench Edge Surface | 7.01 | Trase 2 / 7.01 / Utility Trench Edge Surface / Line
Trase 2 / Geotextile / Edge Right Line | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_RIGHT_EDGE | Trase 2 / Geotextile / Edge Right Line
Trase 2 / Geotextile / Slope Change Bottom Left Line | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_LEFT_SLOPE_CHANGE_BOTTOM | Trase 2 / Geotextile / Slope Change Bottom Left Line
Trase 2 / Foundation / Slope Change Top Left Line | StakeOutStringEmbedment | Foundation | TRENCH_LOWER_BEDDING_LEFT_SLOPE_CHANGE_TOP | Trase 2 / Foundation / Slope Change Top Left Line
Trase 2 / Side Protection / Slope Change Top Left Line | StakeOutStringEmbedment | Side Protection | TRENCH_SIDEFILL_LEFT_SLOPE_CHANGE_TOP | Trase 2 / Side Protection / Slope Change Top Left Line
2 x Trase 3 / -4.01 / Utility Trench Bottom / Line | UtilityTrenchBottomEdge | Utility Trench Bottom | -4.01 | Trase 3 / -4.01 / Utility Trench Bottom / Line
2 x Trase 3 / -1.01 / Utility Trench Bottom / Line | UtilityTrenchBottomEdge | Utility Trench Bottom | -1.01 | Trase 3 / -1.01 / Utility Trench Bottom / Line
2 x Trase 3 / 4.01 / Utility Trench Bottom / Line | UtilityTrenchBottomEdge | Utility Trench Bottom | 4.01 | Trase 3 / 4.01 / Utility Trench Bottom / Line
2 x Trase 3 / 6.01 / Utility Trench Edge Surface / Line | UtilityTrenchEdgeSurfaceEdge | Utility Trench Edge Surface | 6.01 | Trase 3 / 6.01 / Utility Trench Edge Surface / Line
2 x Trase 3 / 1.01 / Utility Trench Bottom / Line | UtilityTrenchBottomEdge | Utility Trench Bottom | 1.01 | Trase 3 / 1.01 / Utility Trench Bottom / Line
Trase 3 / Roadbed / Edge Left Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_LEFT_EDGE | Trase 3 / Roadbed / Edge Left Line
2 x Trase 3 / Roadbed / Slope Change Top Right Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_RIGHT_SLOPE_CHANGE_TOP | Trase 3 / Roadbed / Slope Change Top Right Line
2 x Trase 3 / Roadbed / Slope Change Bottom Left Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_LEFT_SLOPE_CHANGE_BOTTOM | Trase 3 / Roadbed / Slope Change Bottom Left Line
2 x Trase 3 / Roadbed / Slope Change Bottom Right Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_RIGHT_SLOPE_CHANGE_BOTTOM | Trase 3 / Roadbed / Slope Change Bottom Right Line
2 x Trase 3 / Roadbed / Edge Right Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_RIGHT_EDGE | Trase 3 / Roadbed / Edge Right Line
2 x Trase 3 / Roadbed / Slope Change Top Left Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_LEFT_SLOPE_CHANGE_TOP | Trase 3 / Roadbed / Slope Change Top Left Line
2 x Trase 3 / Roadbed / Centre Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_CENTRELINE | Trase 3 / Roadbed / Centre Line
2 x Trase 3 / Foundation / Edge Right Line | StakeOutStringEmbedment | Foundation | TRENCH_LOWER_BEDDING_RIGHT_EDGE | Trase 3 / Foundation / Edge Right Line
2 x Trase 3 / Geotextile / Edge Left Line | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_LEFT_EDGE | Trase 3 / Geotextile / Edge Left Line
2 x Trase 3 / Geotextile / Slope Change Bottom Left Line | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_LEFT_SLOPE_CHANGE_BOTTOM | Trase 3 / Geotextile / Slope Change Bottom Left Line
2 x Trase 3 / Geotextile / Slope Change Top Left Line | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_LEFT_SLOPE_CHANGE_TOP | Trase 3 / Geotextile / Slope Change Top Left Line
2 x Trase 3 / Side Protection / Edge Right Line | StakeOutStringEmbedment | Side Protection | TRENCH_SIDEFILL_RIGHT_EDGE | Trase 3 / Side Protection / Edge Right Line
2 x Trase 3 / Geotextile / Centre Line 2 | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_CENTRELINE | Trase 3 / Geotextile / Centre Line 2
2 x Trase 3 / Geotextile / Centre Line 1 | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_CENTRELINE | Trase 3 / Geotextile / Centre Line 1
2 x Trase 3 / Geotextile / Slope Change Bottom Right Line | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_RIGHT_SLOPE_CHANGE_BOTTOM | Trase 3 / Geotextile / Slope Change Bottom Right Line
Trase 3 / SubgradeSurface Outside Pavement / Edge Left Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_LEFT_EDGE | Trase 3 / SubgradeSurface Outside Pavement / Edge Left Line
2 x Trase 3 / Geotextile / Edge Right Line | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_RIGHT_EDGE | Trase 3 / Geotextile / Edge Right Line
2 x Trase 3 / Geotextile / Slope Change Top Right Line | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_RIGHT_SLOPE_CHANGE_TOP | Trase 3 / Geotextile / Slope Change Top Right Line
2 x Trase 3 / SubgradeSurface Outside Pavement / Centre Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_CENTRELINE | Trase 3 / SubgradeSurface Outside Pavement / Centre Line
2 x Trase 3 / SubgradeSurface Outside Pavement / Slope Change Top Right Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_RIGHT_SLOPE_CHANGE_TOP | Trase 3 / SubgradeSurface Outside Pavement / Slope Change Top Right Line
2 x Trase 3 / SubgradeSurface Outside Pavement / Slope Change Top Left Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_LEFT_SLOPE_CHANGE_TOP | Trase 3 / SubgradeSurface Outside Pavement / Slope Change Top Left Line
2 x Trase 3 / SubgradeSurface Outside Pavement / Slope Change Bottom Left Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_LEFT_SLOPE_CHANGE_BOTTOM | Trase 3 / SubgradeSurface Outside Pavement / Slope Change Bottom Left Line
2 x Trase 3 / SubgradeSurface Outside Pavement / Slope Change Bottom Right Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_RIGHT_SLOPE_CHANGE_BOTTOM | Trase 3 / SubgradeSurface Outside Pavement / Slope Change Bottom Right Line
2 x Trase 3 / SubgradeSurface Outside Pavement / Edge Right Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_RIGHT_EDGE | Trase 3 / SubgradeSurface Outside Pavement / Edge Right Line
2 x Trase 3 / Foundation / Edge Left Line | StakeOutStringEmbedment | Foundation | TRENCH_LOWER_BEDDING_LEFT_EDGE | Trase 3 / Foundation / Edge Left Line
2 x Trase 3 / Protection / Edge Left Line | StakeOutStringEmbedment | Protection | TRENCH_INITIAL_BACKFILL_LEFT_EDGE | Trase 3 / Protection / Edge Left Line
2 x Trase 3 / Side Protection / Edge Left Line | StakeOutStringEmbedment | Side Protection | TRENCH_SIDEFILL_LEFT_EDGE | Trase 3 / Side Protection / Edge Left Line
2 x Trase9 / -6.01 / Utility Trench Edge Surface / Line | UtilityTrenchEdgeSurfaceEdge | Utility Trench Edge Surface | -6.01 | Trase9 / -6.01 / Utility Trench Edge Surface / Line
Trase 3 / SubgradeSurface Outside Pavement / Edge Left Line 1 | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_LEFT_EDGE | Trase 3 / SubgradeSurface Outside Pavement / Edge Left Line 1
Trase 3 / Roadbed / Edge Left Line 1 | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_LEFT_EDGE | Trase 3 / Roadbed / Edge Left Line 1
Trase8 / -6.01 / Utility Trench Edge Surface / Line | UtilityTrenchEdgeSurfaceEdge | Utility Trench Edge Surface | -6.01 | Trase8 / -6.01 / Utility Trench Edge Surface / Line
Trase8 / -4.01 / Utility Trench Bottom / Line | UtilityTrenchBottomEdge | Utility Trench Bottom | -4.01 | Trase8 / -4.01 / Utility Trench Bottom / Line
Trase8 / -1.01 / Utility Trench Bottom / Line | UtilityTrenchBottomEdge | Utility Trench Bottom | -1.01 | Trase8 / -1.01 / Utility Trench Bottom / Line
Trase8 / 6.01 / Utility Trench Edge Surface / Line | UtilityTrenchEdgeSurfaceEdge | Utility Trench Edge Surface | 6.01 | Trase8 / 6.01 / Utility Trench Edge Surface / Line
Trase8 / Roadbed / Edge Left Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_LEFT_EDGE | Trase8 / Roadbed / Edge Left Line
Trase8 / 4.01 / Utility Trench Bottom / Line | UtilityTrenchBottomEdge | Utility Trench Bottom | 4.01 | Trase8 / 4.01 / Utility Trench Bottom / Line
Trase8 / 1.01 / Utility Trench Bottom / Line | UtilityTrenchBottomEdge | Utility Trench Bottom | 1.01 | Trase8 / 1.01 / Utility Trench Bottom / Line
Trase8 / Roadbed / Slope Change Top Right Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_RIGHT_SLOPE_CHANGE_TOP | Trase8 / Roadbed / Slope Change Top Right Line
Trase8 / Roadbed / Slope Change Bottom Right Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_RIGHT_SLOPE_CHANGE_BOTTOM | Trase8 / Roadbed / Slope Change Bottom Right Line
Trase8 / Roadbed / Edge Right Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_RIGHT_EDGE | Trase8 / Roadbed / Edge Right Line
Trase8 / Roadbed / Slope Change Bottom Left Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_LEFT_SLOPE_CHANGE_BOTTOM | Trase8 / Roadbed / Slope Change Bottom Left Line
Trase8 / Roadbed / Centre Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_CENTRELINE | Trase8 / Roadbed / Centre Line
Trase8 / Roadbed / Slope Change Top Left Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_LEFT_SLOPE_CHANGE_TOP | Trase8 / Roadbed / Slope Change Top Left Line
Trase8 / Foundation / Edge Right Line | StakeOutStringEmbedment | Foundation | TRENCH_LOWER_BEDDING_RIGHT_EDGE | Trase8 / Foundation / Edge Right Line
Trase8 / Side Protection / Edge Left Line | StakeOutStringEmbedment | Side Protection | TRENCH_SIDEFILL_LEFT_EDGE | Trase8 / Side Protection / Edge Left Line
Trase8 / Foundation / Edge Left Line | StakeOutStringEmbedment | Foundation | TRENCH_LOWER_BEDDING_LEFT_EDGE | Trase8 / Foundation / Edge Left Line
Trase8 / Protection / Edge Right Line | StakeOutStringEmbedment | Protection | TRENCH_INITIAL_BACKFILL_RIGHT_EDGE | Trase8 / Protection / Edge Right Line
Trase8 / Protection / Edge Left Line | StakeOutStringEmbedment | Protection | TRENCH_INITIAL_BACKFILL_LEFT_EDGE | Trase8 / Protection / Edge Left Line
Trase8 / Geotextile / Slope Change Top Left Line | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_LEFT_SLOPE_CHANGE_TOP | Trase8 / Geotextile / Slope Change Top Left Line
Trase8 / Geotextile / Slope Change Top Right Line | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_RIGHT_SLOPE_CHANGE_TOP | Trase8 / Geotextile / Slope Change Top Right Line
Trase8 / Side Protection / Edge Right Line | StakeOutStringEmbedment | Side Protection | TRENCH_SIDEFILL_RIGHT_EDGE | Trase8 / Side Protection / Edge Right Line
Trase8 / Geotextile / Edge Left Line | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_LEFT_EDGE | Trase8 / Geotextile / Edge Left Line
Trase8 / Geotextile / Slope Change Bottom Left Line | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_LEFT_SLOPE_CHANGE_BOTTOM | Trase8 / Geotextile / Slope Change Bottom Left Line
Trase8 / Geotextile / Centre Line 1 | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_CENTRELINE | Trase8 / Geotextile / Centre Line 1
Trase8 / SubgradeSurface Outside Pavement / Slope Change Bottom Left Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_LEFT_SLOPE_CHANGE_BOTTOM | Trase8 / SubgradeSurface Outside Pavement / Slope Change Bottom Left Line
Trase8 / Geotextile / Slope Change Bottom Right Line | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_RIGHT_SLOPE_CHANGE_BOTTOM | Trase8 / Geotextile / Slope Change Bottom Right Line
Trase8 / Geotextile / Edge Right Line | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_RIGHT_EDGE | Trase8 / Geotextile / Edge Right Line
Trase8 / Geotextile / Centre Line 2 | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_CENTRELINE | Trase8 / Geotextile / Centre Line 2
Trase8 / SubgradeSurface Outside Pavement / Edge Left Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_LEFT_EDGE | Trase8 / SubgradeSurface Outside Pavement / Edge Left Line
Trase8 / SubgradeSurface Outside Pavement / Slope Change Top Right Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_RIGHT_SLOPE_CHANGE_TOP | Trase8 / SubgradeSurface Outside Pavement / Slope Change Top Right Line
Trase8 / SubgradeSurface Outside Pavement / Centre Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_CENTRELINE | Trase8 / SubgradeSurface Outside Pavement / Centre Line
Trase8 / SubgradeSurface Outside Pavement / Slope Change Top Left Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_LEFT_SLOPE_CHANGE_TOP | Trase8 / SubgradeSurface Outside Pavement / Slope Change Top Left Line
Trase8 / SubgradeSurface Outside Pavement / Slope Change Bottom Right Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_RIGHT_SLOPE_CHANGE_BOTTOM | Trase8 / SubgradeSurface Outside Pavement / Slope Change Bottom Right Line
Trase8 / SubgradeSurface Outside Pavement / Edge Right Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_RIGHT_EDGE | Trase8 / SubgradeSurface Outside Pavement / Edge Right Line
2 x Trase9 / -4.01 / Utility Trench Bottom / Line | UtilityTrenchBottomEdge | Utility Trench Bottom | -4.01 | Trase9 / -4.01 / Utility Trench Bottom / Line
2 x Trase9 / 6.01 / Utility Trench Edge Surface / Line | UtilityTrenchEdgeSurfaceEdge | Utility Trench Edge Surface | 6.01 | Trase9 / 6.01 / Utility Trench Edge Surface / Line
Trase9 / -1.01 / Utility Trench Bottom / Line | UtilityTrenchBottomEdge | Utility Trench Bottom | -1.01 | Trase9 / -1.01 / Utility Trench Bottom / Line
Trase9 / 1.01 / Utility Trench Bottom / Line | UtilityTrenchBottomEdge | Utility Trench Bottom | 1.01 | Trase9 / 1.01 / Utility Trench Bottom / Line
2 x Trase9 / 4.01 / Utility Trench Bottom / Line | UtilityTrenchBottomEdge | Utility Trench Bottom | 4.01 | Trase9 / 4.01 / Utility Trench Bottom / Line
2 x Trase9 / Roadbed / Slope Change Bottom Left Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_LEFT_SLOPE_CHANGE_BOTTOM | Trase9 / Roadbed / Slope Change Bottom Left Line
Trase9 / Roadbed / Slope Change Top Right Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_RIGHT_SLOPE_CHANGE_TOP | Trase9 / Roadbed / Slope Change Top Right Line
Trase9 / Roadbed / Slope Change Top Left Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_LEFT_SLOPE_CHANGE_TOP | Trase9 / Roadbed / Slope Change Top Left Line
Trase9 / Roadbed / Centre Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_CENTRELINE | Trase9 / Roadbed / Centre Line
Trase9 / Roadbed / Edge Left Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_LEFT_EDGE | Trase9 / Roadbed / Edge Left Line
2 x Trase9 / Roadbed / Slope Change Bottom Right Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_RIGHT_SLOPE_CHANGE_BOTTOM | Trase9 / Roadbed / Slope Change Bottom Right Line
2 x Trase9 / Protection / Slope Change Bottom Left Line 1 | StakeOutStringEmbedment | Protection | TRENCH_INITIAL_BACKFILL_LEFT_SLOPE_CHANGE_BOTTOM | Trase9 / Protection / Slope Change Bottom Left Line 1
Trase9 / Protection / Slope Change Top Left Line 1 | StakeOutStringEmbedment | Protection | TRENCH_INITIAL_BACKFILL_LEFT_SLOPE_CHANGE_TOP | Trase9 / Protection / Slope Change Top Left Line 1
Trase9 / Roadbed / Edge Right Line | StakeOutStringEmbedment | Roadbed | SUBGRADESURFACE_RIGHT_EDGE | Trase9 / Roadbed / Edge Right Line
Trase9 / Protection / Slope Change Top Left Line 2 | StakeOutStringEmbedment | Protection | TRENCH_INITIAL_BACKFILL_LEFT_SLOPE_CHANGE_TOP | Trase9 / Protection / Slope Change Top Left Line 2
Trase9 / Protection / Edge Left Line | StakeOutStringEmbedment | Protection | TRENCH_INITIAL_BACKFILL_LEFT_EDGE | Trase9 / Protection / Edge Left Line
2 x Trase9 / Protection / Edge Right Line | StakeOutStringEmbedment | Protection | TRENCH_INITIAL_BACKFILL_RIGHT_EDGE | Trase9 / Protection / Edge Right Line
2 x Trase9 / Protection / Slope Change Bottom Right Line | StakeOutStringEmbedment | Protection | TRENCH_INITIAL_BACKFILL_RIGHT_SLOPE_CHANGE_BOTTOM | Trase9 / Protection / Slope Change Bottom Right Line
Trase9 / Foundation / Edge Left Line | StakeOutStringEmbedment | Foundation | TRENCH_LOWER_BEDDING_LEFT_EDGE | Trase9 / Foundation / Edge Left Line
Trase9 / Side Protection / Slope Change Bottom Left Line 2 | StakeOutStringEmbedment | Side Protection | TRENCH_SIDEFILL_LEFT_SLOPE_CHANGE_BOTTOM | Trase9 / Side Protection / Slope Change Bottom Left Line 2
Trase9 / Foundation / Edge Right Line | StakeOutStringEmbedment | Foundation | TRENCH_LOWER_BEDDING_RIGHT_EDGE | Trase9 / Foundation / Edge Right Line
Trase9 / Side Protection / Slope Change Top Right Line | StakeOutStringEmbedment | Side Protection | TRENCH_SIDEFILL_RIGHT_SLOPE_CHANGE_TOP | Trase9 / Side Protection / Slope Change Top Right Line
Trase9 / Geotextile / Centre Line 2 | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_CENTRELINE | Trase9 / Geotextile / Centre Line 2
Trase9 / Side Protection / Slope Change Top Left Line 1 | StakeOutStringEmbedment | Side Protection | TRENCH_SIDEFILL_LEFT_SLOPE_CHANGE_TOP | Trase9 / Side Protection / Slope Change Top Left Line 1
Trase9 / Geotextile / Slope Change Top Right Line | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_RIGHT_SLOPE_CHANGE_TOP | Trase9 / Geotextile / Slope Change Top Right Line
Trase9 / Geotextile / Slope Change Bottom Right Line | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_RIGHT_SLOPE_CHANGE_BOTTOM | Trase9 / Geotextile / Slope Change Bottom Right Line
Trase9 / Geotextile / Centre Line 1 | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_CENTRELINE | Trase9 / Geotextile / Centre Line 1
Trase9 / SubgradeSurface Outside Pavement / Slope Change Top Left Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_LEFT_SLOPE_CHANGE_TOP | Trase9 / SubgradeSurface Outside Pavement / Slope Change Top Left Line
Trase9 / SubgradeSurface Outside Pavement / Centre Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_CENTRELINE | Trase9 / SubgradeSurface Outside Pavement / Centre Line
Trase9 / SubgradeSurface Outside Pavement / Edge Left Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_LEFT_EDGE | Trase9 / SubgradeSurface Outside Pavement / Edge Left Line
2 x Trase9 / SubgradeSurface Outside Pavement / Slope Change Bottom Left Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_LEFT_SLOPE_CHANGE_BOTTOM | Trase9 / SubgradeSurface Outside Pavement / Slope Change Bottom Left Line
2 x Trase9 / Side Protection / Edge Right Line | StakeOutStringEmbedment | Side Protection | TRENCH_SIDEFILL_RIGHT_EDGE | Trase9 / Side Protection / Edge Right Line
Trase9 / Side Protection / Slope Change Bottom Left Line 1 | StakeOutStringEmbedment | Side Protection | TRENCH_SIDEFILL_LEFT_SLOPE_CHANGE_BOTTOM | Trase9 / Side Protection / Slope Change Bottom Left Line 1
Trase9 / SubgradeSurface Outside Pavement / Edge Right Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_RIGHT_EDGE | Trase9 / SubgradeSurface Outside Pavement / Edge Right Line
Trase9 / SubgradeSurface Outside Pavement / Slope Change Top Right Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_RIGHT_SLOPE_CHANGE_TOP | Trase9 / SubgradeSurface Outside Pavement / Slope Change Top Right Line
2 x Trase9 / SubgradeSurface Outside Pavement / Slope Change Bottom Right Line | StakeOutStringEmbedment | SubgradeSurface Outside Pavement | SUBGRADESURFACE_OUTSIDEPAVEMENT_RIGHT_SLOPE_CHANGE_BOTTOM | Trase9 / SubgradeSurface Outside Pavement / Slope Change Bottom Right Line
Trase9 / Protection / Slope Change Top Left Line | StakeOutStringEmbedment | Protection | TRENCH_INITIAL_BACKFILL_LEFT_SLOPE_CHANGE_TOP | Trase9 / Protection / Slope Change Top Left Line
Trase9 / -7.01 / Utility Trench Edge Surface / Line | UtilityTrenchEdgeSurfaceEdge | Utility Trench Edge Surface | -7.01 | Trase9 / -7.01 / Utility Trench Edge Surface / Line
Trase9 / Side Protection / Slope Change Top Left Line 2 | StakeOutStringEmbedment | Side Protection | TRENCH_SIDEFILL_LEFT_SLOPE_CHANGE_TOP | Trase9 / Side Protection / Slope Change Top Left Line 2
Trase9 / Protection / Slope Change Bottom Left Line 2 | StakeOutStringEmbedment | Protection | TRENCH_INITIAL_BACKFILL_LEFT_SLOPE_CHANGE_BOTTOM | Trase9 / Protection / Slope Change Bottom Left Line 2
Trase9 / 7.01 / Utility Trench Edge Surface / Line | UtilityTrenchEdgeSurfaceEdge | Utility Trench Edge Surface | 7.01 | Trase9 / 7.01 / Utility Trench Edge Surface / Line
Trase9 / Side Protection / Edge Left Line | StakeOutStringEmbedment | Side Protection | TRENCH_SIDEFILL_LEFT_EDGE | Trase9 / Side Protection / Edge Left Line
Trase9 / Protection / Slope Change Bottom Left Line 3 | StakeOutStringEmbedment | Protection | TRENCH_INITIAL_BACKFILL_LEFT_SLOPE_CHANGE_BOTTOM | Trase9 / Protection / Slope Change Bottom Left Line 3
Trase9 / Side Protection / Slope Change Bottom Right Line | StakeOutStringEmbedment | Side Protection | TRENCH_SIDEFILL_RIGHT_SLOPE_CHANGE_BOTTOM | Trase9 / Side Protection / Slope Change Bottom Right Line
Trase9 / Geotextile / Edge Left Line 2 | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_LEFT_EDGE | Trase9 / Geotextile / Edge Left Line 2
Trase9 / Side Protection / Slope Change Bottom Left Line | StakeOutStringEmbedment | Side Protection | TRENCH_SIDEFILL_LEFT_SLOPE_CHANGE_BOTTOM | Trase9 / Side Protection / Slope Change Bottom Left Line
Trase9 / Protection / Slope Change Top Right Line 1 | StakeOutStringEmbedment | Protection | TRENCH_INITIAL_BACKFILL_RIGHT_SLOPE_CHANGE_TOP | Trase9 / Protection / Slope Change Top Right Line 1
Trase9 / Side Protection / Slope Change Top Left Line | StakeOutStringEmbedment | Side Protection | TRENCH_SIDEFILL_LEFT_SLOPE_CHANGE_TOP | Trase9 / Side Protection / Slope Change Top Left Line
Trase9 / Protection / Slope Change Top Right Line 2 | StakeOutStringEmbedment | Protection | TRENCH_INITIAL_BACKFILL_RIGHT_SLOPE_CHANGE_TOP | Trase9 / Protection / Slope Change Top Right Line 2
Trase9 / Geotextile / Slope Change Top Left Line | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_LEFT_SLOPE_CHANGE_TOP | Trase9 / Geotextile / Slope Change Top Left Line
Trase9 / Geotextile / Edge Right Line 1 | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_RIGHT_EDGE | Trase9 / Geotextile / Edge Right Line 1
Trase9 / Geotextile / Edge Left Line 1 | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_LEFT_EDGE | Trase9 / Geotextile / Edge Left Line 1
Trase9 / Geotextile / Slope Change Bottom Left Line | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_LEFT_SLOPE_CHANGE_BOTTOM | Trase9 / Geotextile / Slope Change Bottom Left Line
Trase9 / Geotextile / Edge Right Line 2 | StakeOutStringEmbedment | Geotextile | TRENCH_GEOTEXTILE_RIGHT_EDGE | Trase9 / Geotextile / Edge Right Line 2

# IfcBuiltElement: GEOTEXTILE (10)
In: Trase5|WATER AND SEWER
Common - TYPEID: Geotextile; VIPSSURFACENO: TRENCH_GEOTEXTILE
Name | VIPSSURFACENAME | ShortestHorizontalLength (m) | LongestHorizontalLength (m) | ProjectedAreaInTheHorizontalPlane (m2)
Trase4 / Geotextile | Trase4 / Geotextile | 0.0465167 | 27.9025 | 39.1401
Trase 1 / Geotextile | Trase 1 / Geotextile | 0.561115 | 38.8561 | 72.7483
Trase6 / Geotextile | Trase6 / Geotextile | 0.0473711 | 26.789 | 22.6064
Trase 2 / Geotextile | Trase 2 / Geotextile | 0.624278 | 65.788 | 253.768
Trase7 / Geotextile | Trase7 / Geotextile | 0.617658 | 7.97777 | 5.06459
Trase5 / Geotextile | Trase5 / Geotextile | 1.20755 | 1.362 | 1.64842
Trase 3 / Geotextile | Trase 3 / Geotextile | 1.303 | 16.084 | 20.9575
Trase9 / Geotextile | Trase9 / Geotextile | 1.05945 | 12.1249 | 12.0517
Trase 3 / Geotextile | Trase 3 / Geotextile | 0.750924 | 70.3003 | 121.013
Trase8 / Geotextile | Trase8 / Geotextile | 1.143 | 10.081 | 11.4483

# IfcCourse: TRENCH_FOUNDATION (16)
In: Trase5|WATER AND SEWER
PredefinedType: USERDEFINED
Common - TYPEID: Foundation; VIPSSURFACENO: TRENCH_LOWER_BEDDING
Name | VIPSSURFACENAME | Volume (m3) | Height (m) | ShortestHorizontalLength (m) | LongestHorizontalLength (m) | ProjectedAreaInTheHorizontalPlane (m2)
Trase5 / Foundation / Solid | Trase5 / Foundation / Solid | 0.13575 | 0.225642 | 0.747551 | 1.362 | 1.0219
Trase4 / Foundation / Solid | Trase4 / Foundation / Solid | 3.28341 | 0.540026 | 0.0465167 | 27.7467 | 24.3015
Trase 1 / Foundation / Solid | Trase 1 / Foundation / Solid | 5.24729 | 0.636394 | 0.024008 | 38.8785 | 45.8573
Trase 2 / Foundation / Solid | Trase 2 / Foundation / Solid | 9.45588 | 1.43616 | 0.380096 | 63.5126 | 203.027
Trase6 / Foundation / Solid | Trase6 / Foundation / Solid | 1.34775 | 0.714407 | 0.0473711 | 12.965 | 9.8226
Trase7 / Foundation / Solid | Trase7 / Foundation / Solid | 0.11392 | 1.09663 | 0.318979 | 3.28826 | 2.17929
Trase7 / Foundation / Solid | Trase7 / Foundation / Solid | 0.00661 | 0.0475934 | 0.424521 | 0.703868 | 0.355904
Trase6 / Foundation / Solid | Trase6 / Foundation / Solid | 0.25473 | 0.153002 | 0.638506 | 4.00047 | 2.7985
Trase6 / Foundation / Solid | Trase6 / Foundation / Solid | 0.01271 | 0.0441279 | 0.588919 | 1.0006 | 0.613712
Trase 2 / Foundation / Solid | Trase 2 / Foundation / Solid | 0.08735 | 0.161142 | 0.719794 | 1.00048 | 0.736395
Trase 3 / Foundation / Solid | Trase 3 / Foundation / Solid | 1.63574 | 0.315679 | 0.753 | 16.084 | 12.1113
Trase 3 / Foundation / Solid | Trase 3 / Foundation / Solid | 8.83244 | 8.8306 | 0.476347 | 70.481 | 82.3949
Trase8 / Foundation / Solid | Trase8 / Foundation / Solid | 1.01863 | 0.223448 | 0.753 | 10.016 | 7.54206
Trase9 / Foundation / Solid | Trase9 / Foundation / Solid | 0.21484 | 0.303087 | 0.817997 | 2 | 1.636
Trase9 / Foundation / Solid | Trase9 / Foundation / Solid | 0.05599 | 0.244693 | 0.0346477 | 3.10304 | 0.963105
Trase9 / Foundation / Solid | Trase9 / Foundation / Solid | 0.32654 | 0.385296 | 0.817988 | 3.04 | 2.48669

# IfcCourse: TRENCH_PROTECTION (12)
In: Trase5|WATER AND SEWER
PredefinedType: USERDEFINED
Common - TYPEID: Protection; VIPSSURFACENO: TRENCH_INITIAL_BACKFILL
Name | VIPSSURFACENAME | Volume (m3) | Height (m) | ShortestHorizontalLength (m) | LongestHorizontalLength (m) | ProjectedAreaInTheHorizontalPlane (m2)
Trase5 / Protection / Solid | Trase5 / Protection / Solid | 0.43324 | 0.380091 | 1.20755 | 1.362 | 1.64842
Trase4 / Protection / Solid | Trase4 / Protection / Solid | 10.2905 | 0.623129 | 0.0465167 | 27.9025 | 39.1401
Trase 1 / Protection / Solid | Trase 1 / Protection / Solid | 19.3825 | 0.785395 | 0.561115 | 38.8561 | 72.7481
Trase 2 / Protection / Solid | Trase 2 / Protection / Solid | 32.1266 | 1.58516 | 0.624278 | 63.4592 | 251.91
Trase6 / Protection / Solid | Trase6 / Protection / Solid | 0.31832 | 0.482022 | 0.0473711 | 1.27522 | 1.21105
Trase6 / Protection / Solid | Trase6 / Protection / Solid | 1.11107 | 0.464429 | 0.349439 | 8.00156 | 8.06816
Trase 3 / Protection / Solid | Trase 3 / Protection / Solid | 5.56346 | 0.464679 | 1.303 | 16.084 | 20.9575
Trase 3 / Protection / Solid | Trase 3 / Protection / Solid | 27.2098 | 8.92979 | 0.750924 | 70.3003 | 121.101
Trase8 / Protection / Solid | Trase8 / Protection / Solid | 2.98377 | 0.372448 | 1.143 | 10.016 | 11.4483
Trase9 / Protection / Solid | Trase9 / Protection / Solid | 0.04317 | 0.240286 | 0.0206327 | 1.33456 | 0.492794
Trase9 / Protection / Solid | Trase9 / Protection / Solid | 0.02543 | 0.251245 | 0.240193 | 1.00175 | 0.278646
Trase9 / Protection / Solid | Trase9 / Protection / Solid | 0.41972 | 0.313039 | 0.0502263 | 3.04121 | 3.55774

# IfcCourse: TRENCH_SIDEPROTECTION (11)
In: Trase5|WATER AND SEWER
PredefinedType: USERDEFINED
Common - TYPEID: Side Protection; VIPSSURFACENO: TRENCH_SIDEFILL
Name | VIPSSURFACENAME | Volume (m3) | Height (m) | ShortestHorizontalLength (m) | LongestHorizontalLength (m) | ProjectedAreaInTheHorizontalPlane (m2)
Trase5 / Side Protection / Solid | Trase5 / Side Protection / Solid | 0.18094 | 0.240091 | 0.907551 | 1.362 | 1.23982
Trase4 / Side Protection / Solid | Trase4 / Side Protection / Solid | 4.30116 | 0.483129 | 0.0465167 | 27.8009 | 29.4631
Trase 1 / Side Protection / Solid | Trase 1 / Side Protection / Solid | 10.4209 | 0.784852 | 0.42335 | 38.8686 | 56.4689
Trase 2 / Side Protection / Solid | Trase 2 / Side Protection / Solid | 20.4075 | 1.53516 | 0.491057 | 63.4872 | 225.262
Trase6 / Side Protection / Solid | Trase6 / Side Protection / Solid | 1.11944 | 0.600957 | 0.0473711 | 8.96506 | 8.14774
Trase6 / Side Protection / Solid | Trase6 / Side Protection / Solid | 0.24929 | 0.15 | 0.717632 | 4.00244 | 3.30495
Trase 3 / Side Protection / Solid | Trase 3 / Side Protection / Solid | 3.53044 | 0.414679 | 1.003 | 16.084 | 16.1323
Trase 3 / Side Protection / Solid | Trase 3 / Side Protection / Solid | 10.9809 | 8.82979 | 0.0186942 | 70.2265 | 95.9868
Trase8 / Side Protection / Solid | Trase8 / Side Protection / Solid | 0.71935 | 0.162448 | 0.843 | 10.016 | 8.4435
Trase9 / Side Protection / Solid | Trase9 / Side Protection / Solid | 0.54024 | 0.473087 | 1.05945 | 2.00073 | 2.22922
Trase9 / Side Protection / Solid | Trase9 / Side Protection / Solid | 0.92774 | 0.555307 | 1.13299 | 3.04 | 3.44429

# IfcDistributionChamberElement (79)
PredefinedType: TRENCH
Name | In | TYPEID | VIPSSURFACENO | VIPSSURFACENAME | ShortestHorizontalLength (m) | LongestHorizontalLength (m) | ProjectedAreaInTheHorizontalPlane (m2)
Trase5 / -6.01 / Utility Trench Edge Surface | Trase5/ROADSIDE | Utility Trench Edge Surface | -6.01 | Trase5 / -6.01 / Utility Trench Edge Surface | 0.354392 | 1.36219 | 0.498052
Trase5 / -4.01 / Utility Trench Bottom | Trase5/ROADSIDE | Utility Trench Bottom | -4.01 | Trase5 / -4.01 / Utility Trench Bottom | 0.001 | 1.362 | 0.001362
Trase5 / 1.01 / Utility Trench Bottom | Trase5/ROADSIDE | Utility Trench Bottom | 1.01 | Trase5 / 1.01 / Utility Trench Bottom | 0.3 | 1.362 | 0.4086
Trase5 / -1.01 / Utility Trench Bottom | Trase5/ROADSIDE | Utility Trench Bottom | -1.01 | Trase5 / -1.01 / Utility Trench Bottom | 0.3 | 1.362 | 0.4086
Trase5 / 4.01 / Utility Trench Bottom | Trase5/ROADSIDE | Utility Trench Bottom | 4.01 | Trase5 / 4.01 / Utility Trench Bottom | 0.001 | 1.362 | 0.001362
Trase5 / 6.01 / Utility Trench Edge Surface | Trase5/ROADSIDE | Utility Trench Edge Surface | 6.01 | Trase5 / 6.01 / Utility Trench Edge Surface | 0.35988 | 1.36221 | 0.506457
Trase4 / -1.01 / Utility Trench Bottom | Trase4/ROADSIDE | Utility Trench Bottom | -1.01 | Trase4 / -1.01 / Utility Trench Bottom | 0.3 | 27.4941 | 9.65178
Trase4 / -4.01 / Utility Trench Bottom | Trase4/ROADSIDE | Utility Trench Bottom | -4.01 | Trase4 / -4.01 / Utility Trench Bottom | 4.65284 | 27.4086 | 0.0320642
Trase4 / 4.01 / Utility Trench Bottom | Trase4/ROADSIDE | Utility Trench Bottom | 4.01 | Trase4 / 4.01 / Utility Trench Bottom | 4.787 | 27.6957 | 0.0324669
Trase4 / 1.01 / Utility Trench Bottom | Trase4/ROADSIDE | Utility Trench Bottom | 1.01 | Trase4 / 1.01 / Utility Trench Bottom | 0.3 | 27.695 | 9.71127
Trase4 / -6.01 / Utility Trench Edge Surface | Trase4/ROADSIDE | Utility Trench Edge Surface | -6.01 | Trase4 / -6.01 / Utility Trench Edge Surface | 0.0457419 | 27.4082 | 13.1441
Trase4 / 6.01 / Utility Trench Edge Surface | Trase4/ROADSIDE | Utility Trench Edge Surface | 6.01 | Trase4 / 6.01 / Utility Trench Edge Surface | 0.0465937 | 27.6957 | 15.8294
Trase 1 / -1.01 / Utility Trench Bottom | Trase 1/ROADSIDE | Utility Trench Bottom | -1.01 | Trase 1 / -1.01 / Utility Trench Bottom | 0.3 | 38.9547 | 22.6878
Trase 1 / -4.01 / Utility Trench Bottom | Trase 1/ROADSIDE | Utility Trench Bottom | -4.01 | Trase 1 / -4.01 / Utility Trench Bottom | 0.0244985 | 38.62 | 0.0538508
Trase 1 / -6.01 / Utility Trench Edge Surface | Trase 1/ROADSIDE | Utility Trench Edge Surface | -6.01 | Trase 1 / -6.01 / Utility Trench Edge Surface | 0.0244654 | 38.5973 | 44.1826
Trase 1 / 1.01 / Utility Trench Bottom | Trase 1/ROADSIDE | Utility Trench Bottom | 1.01 | Trase 1 / 1.01 / Utility Trench Bottom | 0.279772 | 38.9548 | 15.9838
Trase 1 / 6.01 / Utility Trench Edge Surface | Trase 1/ROADSIDE | Utility Trench Edge Surface | 6.01 | Trase 1 / 6.01 / Utility Trench Edge Surface | 0.0548472 | 38.8815 | 47.444
Trase 1 / 4.01 / Utility Trench Bottom | Trase 1/ROADSIDE | Utility Trench Bottom | 4.01 | Trase 1 / 4.01 / Utility Trench Bottom | 0.001 | 38.8816 | 0.0547251
Trase6 / 7.01 / Utility Trench Edge Surface | Trase6/ROADSIDE | Utility Trench Edge Surface | 7.01 | Trase6 / 7.01 / Utility Trench Edge Surface | 0.0146556 | 7.82062 | 0.510989
Trase6 / -7.01 / Utility Trench Edge Surface | Trase6/ROADSIDE | Utility Trench Edge Surface | -7.01 | Trase6 / -7.01 / Utility Trench Edge Surface | 0.00830651 | 7.82066 | 0.473478
Trase6 / 1.01 / Utility Trench Bottom | Trase6/ROADSIDE | Utility Trench Bottom | 1.01 | Trase6 / 1.01 / Utility Trench Bottom | 0.3 | 26.82 | 8.046
Trase 2 / -4.01 / Utility Trench Bottom | Trase 2/ROADSIDE | Utility Trench Bottom | -4.01 | Trase 2 / -4.01 / Utility Trench Bottom | 0.0210811 | 65.5281 | 0.105209
Trase 2 / 1.01 / Utility Trench Bottom | Trase 2/ROADSIDE | Utility Trench Bottom | 1.01 | Trase 2 / 1.01 / Utility Trench Bottom | 0.0578422 | 65.94 | 28.5542
Trase 2 / 4.01 / Utility Trench Bottom | Trase 2/ROADSIDE | Utility Trench Bottom | 4.01 | Trase 2 / 4.01 / Utility Trench Bottom | 0.0269767 | 65.5538 | 0.107749
Trase 2 / -1.01 / Utility Trench Bottom | Trase 2/ROADSIDE | Utility Trench Bottom | -1.01 | Trase 2 / -1.01 / Utility Trench Bottom | 0.3 | 65.94 | 28.614
Trase 2 / -6.01 / Utility Trench Edge Surface | Trase 2/ROADSIDE | Utility Trench Edge Surface | -6.01 | Trase 2 / -6.01 / Utility Trench Edge Surface | 0.597617 | 65.5303 | 208.111
Trase 2 / 6.01 / Utility Trench Edge Surface | Trase 2/ROADSIDE | Utility Trench Edge Surface | 6.01 | Trase 2 / 6.01 / Utility Trench Edge Surface | 0.684375 | 65.554 | 202.163
Trase6 / -6.01 / Utility Trench Edge Surface | Trase6/ROADSIDE | Utility Trench Edge Surface | -6.01 | Trase6 / -6.01 / Utility Trench Edge Surface | 0.0497953 | 19 | 3.07638
Trase6 / 6.01 / Utility Trench Edge Surface | Trase6/ROADSIDE | Utility Trench Edge Surface | 6.01 | Trase6 / 6.01 / Utility Trench Edge Surface | 0.0485533 | 18 | 2.75212
Trase6 / 4.01 / Utility Trench Bottom | Trase6/ROADSIDE | Utility Trench Bottom | 4.01 | Trase6 / 4.01 / Utility Trench Bottom | 0.0146556 | 19.0001 | 0.0258278
Trase6 / -4.01 / Utility Trench Bottom | Trase6/ROADSIDE | Utility Trench Bottom | -4.01 | Trase6 / -4.01 / Utility Trench Bottom | 0.00830651 | 19 | 0.0226533
Trase6 / -1.01 / Utility Trench Bottom | Trase6/ROADSIDE | Utility Trench Bottom | -1.01 | Trase6 / -1.01 / Utility Trench Bottom | 0.3 | 26.82 | 8.046
Trase7 / -6.01 / Utility Trench Edge Surface | Trase7/ROADSIDE | Utility Trench Edge Surface | -6.01 | Trase7 / -6.01 / Utility Trench Edge Surface | 0.0072004 | 1.78869 | 0.258216
Trase7 / 4.01 / Utility Trench Bottom | Trase7/ROADSIDE | Utility Trench Bottom | 4.01 | Trase7 / 4.01 / Utility Trench Bottom | 0.00557511 | 2.19879 | 0.00549739
Trase7 / -1.01 / Utility Trench Bottom | Trase7/ROADSIDE | Utility Trench Bottom | -1.01 | Trase7 / -1.01 / Utility Trench Bottom | 0.0272317 | 6.64804 | 2.27175
Trase7 / -4.01 / Utility Trench Bottom | Trase7/ROADSIDE | Utility Trench Bottom | -4.01 | Trase7 / -4.01 / Utility Trench Bottom | 0.775637 | 0.950306 | 0.0203722
Trase7 / 1.01 / Utility Trench Bottom | Trase7/ROADSIDE | Utility Trench Bottom | 1.01 | Trase7 / 1.01 / Utility Trench Bottom | 0.3 | 6.88119 | 2.32438
Trase7 / 6.01 / Utility Trench Edge Surface | Trase7/ROADSIDE | Utility Trench Edge Surface | 6.01 | Trase7 / 6.01 / Utility Trench Edge Surface | 0.525881 | 3.36451 | 0.299374
Trase7 / -4.01 / Utility Trench Bottom | Trase7/ROADSIDE | Utility Trench Bottom | -4.01 | Trase7 / -4.01 / Utility Trench Bottom | 0.0043791 | 1.00001 | 0.00218955
Trase7 / 4.01 / Utility Trench Bottom | Trase7/ROADSIDE | Utility Trench Bottom | 4.01 | Trase7 / 4.01 / Utility Trench Bottom | 0.00783897 | 1.00003 | 0.00441949
Trase7 / 7.01 / Utility Trench Edge Surface | Trase7/ROADSIDE | Utility Trench Edge Surface | 7.01 | Trase7 / 7.01 / Utility Trench Edge Surface | 0.00557511 | 1.00001 | 0.00328755
Trase7 / 6.01 / Utility Trench Edge Surface | Trase7/ROADSIDE | Utility Trench Edge Surface | 6.01 | Trase7 / 6.01 / Utility Trench Edge Surface | 2.00001 | 2.00003 | 0.00784121
Trase7 / -6.01 / Utility Trench Edge Surface | Trase7/ROADSIDE | Utility Trench Edge Surface | -6.01 | Trase7 / -6.01 / Utility Trench Edge Surface | 0.00644524 | 0.683037 | 0.00220105
Trase7 / -7.01 / Utility Trench Edge Surface | Trase7/ROADSIDE | Utility Trench Edge Surface | -7.01 | Trase7 / -7.01 / Utility Trench Edge Surface | 0.0043791 | 4.68308 | 0.0422045
Trase7 / 7.01 / Utility Trench Edge Surface | Trase7/ROADSIDE | Utility Trench Edge Surface | 7.01 | Trase7 / 7.01 / Utility Trench Edge Surface | 0.00783897 | 2.00018 | 0.00981057
Trase 3 / -6.01 / Utility Trench Edge Surface | Trase 3/ROADSIDE | Utility Trench Edge Surface | -6.01 | Trase 3 / -6.01 / Utility Trench Edge Surface | 0.507464 | 16.1087 | 14.4137
Trase 3 / 6.01 / Utility Trench Edge Surface | Trase 3/ROADSIDE | Utility Trench Edge Surface | 6.01 | Trase 3 / 6.01 / Utility Trench Edge Surface | 0.375144 | 16.1434 | 14.7336
Trase 3 / -6.01 / Utility Trench Edge Surface | Trase 3/ROADSIDE | Utility Trench Edge Surface | -6.01 | Trase 3 / -6.01 / Utility Trench Edge Surface | 0.164709 | 69.765 | 57.1106
Trase 3 / -1.01 / Utility Trench Bottom | Trase 3/ROADSIDE | Utility Trench Bottom | -1.01 | Trase 3 / -1.01 / Utility Trench Bottom | 0.0558537 | 68.553 | 25.7411
Trase 3 / 1.01 / Utility Trench Bottom | Trase 3/ROADSIDE | Utility Trench Bottom | 1.01 | Trase 3 / 1.01 / Utility Trench Bottom | 0.0361323 | 73.1807 | 25.6672
Trase 2 / 7.01 / Utility Trench Edge Surface | Trase 2/ROADSIDE | Utility Trench Edge Surface | 7.01 | Trase 2 / 7.01 / Utility Trench Edge Surface | 0.0269767 | 0.301009 | 0.00846094
Trase 2 / -7.01 / Utility Trench Edge Surface | Trase 2/ROADSIDE | Utility Trench Edge Surface | -7.01 | Trase 2 / -7.01 / Utility Trench Edge Surface | 0.0210811 | 0.301406 | 0.00869774
Trase 3 / -4.01 / Utility Trench Bottom | Trase 3/ROADSIDE | Utility Trench Bottom | -4.01 | Trase 3 / -4.01 / Utility Trench Bottom | 16.084 | 16.084 | 0.016084
Trase 3 / -1.01 / Utility Trench Bottom | Trase 3/ROADSIDE | Utility Trench Bottom | -1.01 | Trase 3 / -1.01 / Utility Trench Bottom | 0.3 | 16.084 | 4.8252
Trase 3 / 1.01 / Utility Trench Bottom | Trase 3/ROADSIDE | Utility Trench Bottom | 1.01 | Trase 3 / 1.01 / Utility Trench Bottom | 0.3 | 16.084 | 4.8252
Trase 3 / 4.01 / Utility Trench Bottom | Trase 3/ROADSIDE | Utility Trench Bottom | 4.01 | Trase 3 / 4.01 / Utility Trench Bottom | 16.084 | 16.084 | 0.016084
Trase9 / -1.01 / Utility Trench Bottom | Trase9/ROADSIDE | Utility Trench Bottom | -1.01 | Trase9 / -1.01 / Utility Trench Bottom | 0.3355 | 12.04 | 4.03942
Trase9 / 1.01 / Utility Trench Bottom | Trase9/ROADSIDE | Utility Trench Bottom | 1.01 | Trase9 / 1.01 / Utility Trench Bottom | 0.3355 | 12.04 | 4.03942
Trase9 / 4.01 / Utility Trench Bottom | Trase9/ROADSIDE | Utility Trench Bottom | 4.01 | Trase9 / 4.01 / Utility Trench Bottom | 0.001 | 6.00003 | 0.00991774
Trase9 / -4.01 / Utility Trench Bottom | Trase9/ROADSIDE | Utility Trench Bottom | -4.01 | Trase9 / -4.01 / Utility Trench Bottom | 0.001 | 3.00042 | 0.0174338
Trase 3 / 6.01 / Utility Trench Edge Surface | Trase 3/ROADSIDE | Utility Trench Edge Surface | 6.01 | Trase 3 / 6.01 / Utility Trench Edge Surface | 0.073103 | 6.68993 | 7.28659
Trase 3 / -4.01 / Utility Trench Bottom | Trase 3/ROADSIDE | Utility Trench Bottom | -4.01 | Trase 3 / -4.01 / Utility Trench Bottom | 0.001 | 69.7666 | 20.956
Trase 3 / 4.01 / Utility Trench Bottom | Trase 3/ROADSIDE | Utility Trench Bottom | 4.01 | Trase 3 / 4.01 / Utility Trench Bottom | 0.001 | 70.1528 | 19.9537
Trase 3 / -6.01 / Utility Trench Edge Surface | Trase 3/ROADSIDE | Utility Trench Edge Surface | -6.01 | Trase 3 / -6.01 / Utility Trench Edge Surface | 0.810038 | 5.58482 | 5.60115
Trase 3 / 6.01 / Utility Trench Edge Surface | Trase 3/ROADSIDE | Utility Trench Edge Surface | 6.01 | Trase 3 / 6.01 / Utility Trench Edge Surface | 0.0988901 | 73.1401 | 34.8603
Trase8 / -4.01 / Utility Trench Bottom | Trase8/ROADSIDE | Utility Trench Bottom | -4.01 | Trase8 / -4.01 / Utility Trench Bottom | 10.016 | 10.016 | 0.010016
Trase8 / -1.01 / Utility Trench Bottom | Trase8/ROADSIDE | Utility Trench Bottom | -1.01 | Trase8 / -1.01 / Utility Trench Bottom | 0.3 | 10.016 | 3.0048
Trase8 / 1.01 / Utility Trench Bottom | Trase8/ROADSIDE | Utility Trench Bottom | 1.01 | Trase8 / 1.01 / Utility Trench Bottom | 0.3 | 10.016 | 3.0048
Trase8 / 4.01 / Utility Trench Bottom | Trase8/ROADSIDE | Utility Trench Bottom | 4.01 | Trase8 / 4.01 / Utility Trench Bottom | 10.016 | 10.016 | 0.010016
Trase8 / -6.01 / Utility Trench Edge Surface | Trase8/ROADSIDE | Utility Trench Edge Surface | -6.01 | Trase8 / -6.01 / Utility Trench Edge Surface | 0.827867 | 10.0172 | 7.90726
