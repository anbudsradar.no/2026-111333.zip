Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: ViewDefinition [Alignment-basedView]
File name: C:\Users\klaids\AppData\Local\Temp\Trimble\ConnectFolder\Eksport til IFC-fil av m_f-veg-70400.ifc
Time: 2026-02-04T09:27:55
Author: Klaid Schjetne
Written by: Ifc Engine <1.0.1.1369>
Made in: Trimble Inc. - Novapoint - 27.0.1276.0
Authorization: Klaid Schjetne

# IfcProject, Default Project
Description: Description of the Project

# IfcSite, Default Site
RefLatitude: 10, 17, 27; RefLongitude: 63, 9, 12; RefElevation: 32.9575 m

# IfcActor (2)
Name
 | Pset_Address - Purpose: OFFICE; Country: Norway


# IfcAnnotation (26)
In: m_f_GS-Veg-70400|ROADSEGMENT
Description: StakeOutStringTopLevel; PredefinedType: SURVEY
Name
5 x m_f_GS-Veg-70400 / 6.11 / H. Jordskj. 11 / Line
2 x m_f_GS-Veg-70400 / -7.11 / V. Fylling 11 / Line
2 x m_f_GS-Veg-70400 / -6.11 / V. Jordskj. 11 / Line
2 x m_f_GS-Veg-70400 / 6.10 / H.Jordskj 10 / Line
3 x m_f_GS-Veg-70400 / 4.01 / H. Grøft 01 / Line
2 x m_f_GS-Veg-70400 / 7.11 / H. Fylling 11 / Line
m_f_GS-Veg-70400 / -4.01 / V. Grøft 01 / Line
m_f_GS-Veg-70400 / 4.02 / H.Grøft 2 / Line
m_f_GS-Veg-70400 / -6.10 / V.Jordskj 10 / Line
m_f_GS-Veg-70400 / -1.01 / V. Felt 01 / Line
m_f_GS-Veg-70400 / 4.03 / H.Grøft 3 / Line
m_f_GS-Veg-70400 / 0 / Pavement / Centre Line
m_f_GS-Veg-70400 / 6.10 / H.Jordskj 10 / Line 1
m_f_GS-Veg-70400 / 2.01 / H. Skulder 01 / Line
m_f_GS-Veg-70400 / -2.01 / V. Skulder 01 / Line
m_f_GS-Veg-70400 / 6.10 / H.Jordskj 10 / Line 2

# IfcCourse (3)
In: m_f_GS-Veg-70400|ROADSEGMENT
PredefinedType: PAVEMENT; Material: Asphalt
Name
m_f_GS-Veg-70400 / Slitelag
m_f_GS-Veg-70400 / Bærelag 1
m_f_GS-Veg-70400 / Bindlag 1

# IfcCourse: ROADSHOULDER_SURFACE (2)
In: m_f_GS-Veg-70400|SHOULDER
PredefinedType: USERDEFINED
Name
m_f_GS-Veg-70400 / 2.01 / H. Skulder 01
m_f_GS-Veg-70400 / -2.01 / V. Skulder 01

# IfcCourse: TRAFFICLANE_SURFACE, m_f_GS-Veg-70400 | -1.01 | V. Felt 01
In: m_f_GS-Veg-70400|CARRIAGEWAY
PredefinedType: USERDEFINED

# IfcDistributionChamberElement (11)
In: m_f_GS-Veg-70400|ROADSIDE
PredefinedType: TRENCH
Name
6 x m_f_GS-Veg-70400 / 4.01 / H. Grøft 01
3 x m_f_GS-Veg-70400 / -4.01 / V. Grøft 01
m_f_GS-Veg-70400 / 4.03 / H.Grøft 3
m_f_GS-Veg-70400 / 4.02 / H.Grøft 2

# IfcEarthworksCut, m_f_GS-Veg-70400 | Jord 1 | Solid
In: Default Site
PredefinedType: CUT

# IfcEarthworksCut: LOWESTCONSTRUCTIONWORKSURFACE, m_f_GS-Veg-70400 | Constructionbed | InCutSoil
In: Default Site
PredefinedType: USERDEFINED

# IfcEarthworksFill (44)
Name | In | PredefinedType
6 x m_f_GS-Veg-70400 / SubgradeSurface Outside Pavement | m_f_GS-Veg-70400/ROADSEGMENT | SUBGRADEBED
6 x m_f_GS-Veg-70400 / 6.10 / H.Jordskj 10 | m_f_GS-Veg-70400/ROADSIDE | SLOPEFILL
5 x m_f_GS-Veg-70400 / 7.11 / H. Fylling 11 | m_f_GS-Veg-70400/ROADSIDE | SLOPEFILL
8 x m_f_GS-Veg-70400 / 6.11 / H. Jordskj. 11 | m_f_GS-Veg-70400/ROADSIDE | SLOPEFILL
3 x m_f_GS-Veg-70400 / SubgradeSurface Inside Pavement / InCutSoil | m_f_GS-Veg-70400/ROADSEGMENT | SUBGRADEBED
4 x m_f_GS-Veg-70400 / -7.11 / V. Fylling 11 | m_f_GS-Veg-70400/ROADSIDE | SLOPEFILL
3 x m_f_GS-Veg-70400 / -6.10 / V.Jordskj 10 | m_f_GS-Veg-70400/ROADSIDE | SLOPEFILL
2 x m_f_GS-Veg-70400 / -6.11 / V. Jordskj. 11 | m_f_GS-Veg-70400/ROADSIDE | SLOPEFILL
4 x m_f_GS-Veg-70400 / Forsterkningslag 1 | m_f_GS-Veg-70400/ROADSEGMENT | SUBGRADEBED | Material: Crushed stone
m_f_GS-Veg-70400 / Filterlag | m_f_GS-Veg-70400/ROADSEGMENT | SUBGRADEBED | Material: Gravel
m_f_GS-Veg-70400 / Filterlag | m_f_GS-Veg-70400/ROADSEGMENT | SUBGRADEBED
m_f_GS-Veg-70400/SUBGRADE | m_f_GS-Veg-70400/ROADSEGMENT | SUBGRADE

# IfcPavement, m_f_GS-Veg-70400|RIGID
In: m_f_GS-Veg-70400|ROADSEGMENT
PredefinedType: RIGID

# IfcRoad: Road, m_f_GS-Veg-70400
PredefinedType: USERDEFINED

# IfcRoadPart (4)
Name | UsageType | PredefinedType
m_f_GS-Veg-70400/ROADSEGMENT | LONGITUDINAL | ROADSEGMENT
m_f_GS-Veg-70400/CARRIAGEWAY | LATERAL | CARRIAGEWAY
m_f_GS-Veg-70400/SHOULDER | LATERAL | SHOULDER
m_f_GS-Veg-70400/ROADSIDE | LATERAL | ROADSIDE
