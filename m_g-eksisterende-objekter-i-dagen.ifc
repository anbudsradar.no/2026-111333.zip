Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverAddonView, ConceptDesignBIM_2010]
File name: m_g-eksisterende-objekter-i-dag.ifc (Edited by Naviate Simple BIM 10.1 version 2)
Time: 2026-03-29T19:57:17
Author: ANDFYG
Written by: ODA SDAI 24.6
Made in: Build

# IfcProject, C16939
LongName: E6 Ny Lundamo bru

# IfcSite
ePset_ModelInfo - ModelName: m_g-eksisterende-objekter-i-dag.ifc; Timestamp: 2026-03-29T19:57:17

# IfcBuilding
ePset_ModelInfo - ModelName: m_g-eksisterende-objekter-i-dag.ifc; Timestamp: 2026-03-29T19:57:17

# IfcBuildingElementProxy (26)
ePset_ModelInfo - ModelName: m_g-eksisterende-objekter-i-dag.ifc; Timestamp: 2026-03-29T19:57:17
Name | Red | Green | Blue
3 x  | 0 | 255 | 0
2 x  | 127 | 159 | 255 | Prosessinfo - P02 Element: D1 Elektro Vei; P04 Prosessnavn: Oppgraving/nedtaking og fjerning/flytting av kabler; P05 Mengde: 1; P03 Prosessnummer: 16.31; P01 Sted: E1 Elektro; P06 Enhet: RS
2 x  | 127 | 159 | 255
2 x  | 0 | 0 | 0
 | 127 | 159 | 255 | Prosessinfo - P02 Element: D1 Elektro Vei; P04 Prosessnavn: Oppgraving/nedtaking og fjerning/flytting av kabler; P05 Mengde: 1; P03 Prosessnummer: 16.31; P01 Sted: E1 Elektro; P06 Enhet: RS; Egenskaper - M01 Armaturnummer: UP; Merknader - M01 Armaturnummer: UP; M11 Mastenummer: KM
 | 0 | 0 | 0 | Prosessinfo - P05 Mengde: 0; Merknader - M01 Armaturnummer: UP; M11 Mastenummer: KM
15 x  | 127 | 0 | 0

# IfcBuildingElementProxy: *U10 (2)
ePset_ModelInfo - ModelName: m_g-eksisterende-objekter-i-dag.ifc; Timestamp: 2026-03-29T19:57:17
Merknader - M12 Materiale mast: Tre; M10 Objektnavn mast: Veglysmast
Prosessinfo - P02 Element: D1 Elektro Vei; P05 Mengde: 1; P03 Prosessnummer: 16.321; P04 Prosessnavn: Demontering av master/stolper, fundamenter og armatur; P01 Sted: E1 Elektro; P06 Enhet: RS
Pset_Draughting - Red: 127; Green: 95; Blue: 0
Name | M11 Mastenummer
 | KM106
 | KM105

# IfcBuildingElementProxy: *U19
ePset_ModelInfo - ModelName: m_g-eksisterende-objekter-i-dag.ifc; Timestamp: 2026-03-29T19:57:17
Prosessinfo - P05 Mengde: 0
Pset_Draughting - Red: 204; Green: 204; Blue: 204

# IfcBuildingElementProxy: *U26
ePset_ModelInfo - ModelName: m_g-eksisterende-objekter-i-dag.ifc; Timestamp: 2026-03-29T19:57:17
Merknader - M11 Mastenummer: KM000; M12 Materiale mast: Stål; M10 Objektnavn mast: Veglysmast
Prosessinfo - P05 Mengde: 0
Pset_Draughting - Red: 204; Green: 204; Blue: 204

# IfcBuildingElementProxy: *U35
ePset_ModelInfo - ModelName: m_g-eksisterende-objekter-i-dag.ifc; Timestamp: 2026-03-29T19:57:17
Merknader - M11 Mastenummer: KM104; M12 Materiale mast: Stål; M10 Objektnavn mast: Veglysmast
Prosessinfo - P02 Element: D1 Elektro Vei; P05 Mengde: 1; P03 Prosessnummer: 16.321; P04 Prosessnavn: Demontering av master/stolper, fundamenter og armatur; P01 Sted: E1 Elektro; P06 Enhet: RS
Pset_Draughting - Red: 0; Green: 0; Blue: 0

# IfcBuildingElementProxy: *U36
ePset_ModelInfo - ModelName: m_g-eksisterende-objekter-i-dag.ifc; Timestamp: 2026-03-29T19:57:17
Merknader - M11 Mastenummer: KM102; M12 Materiale mast: Stål; M10 Objektnavn mast: Veglysmast
Prosessinfo - P02 Element: D1 Elektro Vei; P05 Mengde: 1; P03 Prosessnummer: 16.321; P04 Prosessnavn: Demontering av master/stolper, fundamenter og armatur; P01 Sted: E1 Elektro; P06 Enhet: RS
Pset_Draughting - Red: 0; Green: 0; Blue: 0

# IfcBuildingElementProxy: *U37
ePset_ModelInfo - ModelName: m_g-eksisterende-objekter-i-dag.ifc; Timestamp: 2026-03-29T19:57:17
Merknader - M11 Mastenummer: KM101; M10 Objektnavn mast: Veglysmasy
Prosessinfo - P02 Element: D1 Elektro Vei; P05 Mengde: 1; P03 Prosessnummer: 16.321; P04 Prosessnavn: Demontering av master/stolper, fundamenter og armatur; P01 Sted: E1 Elektro; P06 Enhet: RS
Pset_Draughting - Red: 0; Green: 0; Blue: 0

# IfcBuildingElementProxy: *U38
ePset_ModelInfo - ModelName: m_g-eksisterende-objekter-i-dag.ifc; Timestamp: 2026-03-29T19:57:17
Merknader - M11 Mastenummer: KM103; M12 Materiale mast: Stål; M10 Objektnavn mast: Veglysmast
Prosessinfo - P02 Element: D1 Elektro Vei; P05 Mengde: 1; P03 Prosessnummer: 16.321; P04 Prosessnavn: Demontering av master/stolper, fundamenter og armatur; P01 Sted: E1 Elektro; P06 Enhet: RS
Pset_Draughting - Red: 0; Green: 0; Blue: 0

# IfcBuildingElementProxy: Hsp-mast_dobbel_10m (5)
ePset_ModelInfo - ModelName: m_g-eksisterende-objekter-i-dag.ifc; Timestamp: 2026-03-29T19:57:17
Prosessinfo - P05 Mengde: 0
Pset_Draughting - Red: 211; Green: 211; Blue: 211

# IfcBuildingElementProxy: Lysmast - tre_10m (6)
ePset_ModelInfo - ModelName: m_g-eksisterende-objekter-i-dag.ifc; Timestamp: 2026-03-29T19:57:17
Merknader - M12 Materiale mast: Tre; M10 Objektnavn mast: Veglysmast
Prosessinfo - P02 Element: D1 Elektro Vei; P05 Mengde: 1; P03 Prosessnummer: 16.321; P04 Prosessnavn: Demontering av master/stolper, fundamenter og armatur; P01 Sted: E1 Elektro; P06 Enhet: RS
Pset_Draughting - Red: 127; Green: 95; Blue: 0
Name | M11 Mastenummer
 | KM107
 | KM108
 | KM109
 | KM110
 | KM111
 | KM112

# IfcBuildingElementProxy: Trestolpe (5)
ePset_ModelInfo - ModelName: m_g-eksisterende-objekter-i-dag.ifc; Timestamp: 2026-03-29T19:57:17
Pset_Draughting - Red: 165; Green: 82; Blue: 0
