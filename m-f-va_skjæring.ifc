Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: ViewDefinition [Alignment-basedView]
File name: C:\Users\leilar\AppData\Local\Temp\Trimble\ConnectFolder\m-f-va_skjæring.ifc
Time: 2026-03-17T15:49:28
Author: Leif Gunnar Larsen
Organization: Statens vegvesen
Written by: Ifc Engine <1.0.1.1369>
Made in: Trimble Inc. - Novapoint - 28.0.290.0
Authorization: Leif Gunnar Larsen

# IfcProject, Default Project
Description: Description of the Project

# IfcSite (2)
Name
Default Site | RefLatitude: 10, 17, 30; RefLongitude: 63, 9, 16; RefElevation: 30.0931 m
Trase5

# IfcActor (2)
Name
 | Pset_Address - Purpose: OFFICE; Town: Bodø; Country: Norway


# IfcEarthworksCut (12)
In: Trase5
PredefinedType: CUT
Common - TYPEID: cut_soil_1; VIPSSURFACENO: MATERIAL_01_SOIL
Name | VIPSSURFACENAME | Volume (m3) | Height (m) | ShortestHorizontalLength (m) | LongestHorizontalLength (m) | ProjectedAreaInTheHorizontalPlane (m2)
Trase5 / cut_soil_1 / Solid | Trase5 / cut_soil_1 / Solid | 0.97445 | 0.794347 | 1.31627 | 1.36309 | 1.82443
Trase4 / cut_soil_1 / Solid | Trase4 / cut_soil_1 / Solid | 28.5929 | 2.029 | 0.0457419 | 27.2467 | 48.3943
Trase 1 / cut_soil_1 / Solid | Trase 1 / cut_soil_1 / Solid | 143.407 | 2.54901 | 0.0548472 | 38.8167 | 130.407
Trase 2 / cut_soil_1 / Solid | Trase 2 / cut_soil_1 / Solid | 188.461 | 3.19517 | 0.719794 | 64.53 | 328.225
Trase6 / cut_soil_1 / Solid | Trase6 / cut_soil_1 / Solid | 4.88076 | 1.07139 | 0.0497953 | 17.9793 | 16.6511
Trase7 / cut_soil_1 / Solid | Trase7 / cut_soil_1 / Solid | 0.52009 | 1.09663 | 0.318979 | 4.38743 | 2.56195
Trase7 / cut_soil_1 / Solid | Trase7 / cut_soil_1 / Solid | 0.00655 | 0.0475934 | 0.424521 | 0.703868 | 0.355904
Trase 3 / cut_soil_1 / Solid | Trase 3 / cut_soil_1 / Solid | 42.9694 | 2.62552 | 1.48461 | 16.1434 | 38.8299
Trase 3 / cut_soil_1 / Solid | Trase 3 / cut_soil_1 / Solid | 117.175 | 11.073 | 0.0988901 | 68.861 | 163.813
Trase8 / cut_soil_1 / Solid | Trase8 / cut_soil_1 / Solid | 22.1027 | 1.73303 | 2.23386 | 10.0172 | 21.8988
Trase9 / cut_soil_1 / Solid | Trase9 / cut_soil_1 / Solid | 1.09292 | 0.790289 | 0.034601 | 5.04262 | 3.52763
Trase9 / cut_soil_1 / Solid | Trase9 / cut_soil_1 / Solid | 1.68478 | 0.773027 | 1.19314 | 3.04121 | 3.86532
