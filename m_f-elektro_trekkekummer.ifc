Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverAddonView, ConceptDesignBIM_2010]
File name: m_f-elektro_trekkekummer.ifc (Edited by Naviate Simple BIM 10.1 version 2)
Time: 2026-03-23T20:07:47
Author: ANDFYG
Written by: ODA SDAI 24.6
Made in: Build

# IfcProject, C16939
LongName: E6 Ny Lundamo bru

# IfcSite
ePset_ModelInfo - ModelName: m_f-elektro_trekkekummer.ifc; Timestamp: 2026-03-23T20:07:47

# IfcBuilding
ePset_ModelInfo - ModelName: m_f-elektro_trekkekummer.ifc; Timestamp: 2026-03-23T20:07:47

# IfcBuildingElementProxy (2)
ePset_ModelInfo - ModelName: m_f-elektro_trekkekummer.ifc; Timestamp: 2026-03-23T20:07:47
Merknader - M01 Armaturnummer: UP; M21 Kumnummer: NK
Prosessinfo - P05 Mengde: 0
Pset_Draughting - Red: 0; Green: 0; Blue: 0

# IfcBuildingElementProxy: *U11
ePset_ModelInfo - ModelName: m_f-elektro_trekkekummer.ifc; Timestamp: 2026-03-23T20:07:47
Merknader - M61 Tegningshenvisning: IN001 og IN053; M21 Kumnummer: NK004; M24 Dimensjon (LxBxH): 1420x700x900; M22 TFM-merking trekkekum: +S50VLS71D1=749.001 -NK004; M20 Objektnavn: Trekkekum; M23 Kumtype: TK2
Prosessinfo - P03 Prosessnummer: 44.4614; P02 Element: D1 Elektro Vei; P06 Enhet: stk; P05 Mengde: 1; P04 Prosessnavn: Trekkekum type TK2 skrå 26 grader; P01 Sted: E1 Elektro
Tittelfelt - T10 Kontrollert av: renlie; T09 Utarbeidet av: andfyg; T05 Produsert for: DoV midt; T01 Vegstrekning: Ev006 S70D1 m9800 - S71D1 m340; T04 Bestiller: Thorstein Kjøs Johnsen; T02 Prosjektfase: Konkurransegrunnlag; T07 PROF-nummer: C16939-202; T06 Produsert av: Fagressurs DoV; T03 Dato: 24.03.26; T00 Prosjektnavn: E6 Lundamo bru
Pset_Draughting - Red: 204; Green: 204; Blue: 204

# IfcBuildingElementProxy: *U14
ePset_ModelInfo - ModelName: m_f-elektro_trekkekummer.ifc; Timestamp: 2026-03-23T20:07:47
Prosessinfo - P03 Prosessnummer: 44.4612; P02 Element: D1 Elektro Vei; P04 Prosessnavn: Trekkekum type TK2 skrå 11 grader; P06 Enhet: stk; P05 Mengde: 1; P01 Sted: E1 Elektro
Tittelfelt - T10 Kontrollert av: renlie; T09 Utarbeidet av: andfyg; T05 Produsert for: DoV midt; T01 Vegstrekning: Ev006 S70D1 m9800 - S71D1 m340; T04 Bestiller: Thorstein Kjøs Johnsen; T02 Prosjektfase: Konkurransegrunnlag; T07 PROF-nummer: C16939-202; T06 Produsert av: Fagressurs DoV; T03 Dato: 24.03.26; T00 Prosjektnavn: E6 Lundamo bru
Merknader - M22 TFM-merking trekkekum: +S50VLS71D1=749.001 -NK007; M25 Skrå: 11gr; M61 Tegningshenvisning: IN001 og IN053; M21 Kumnummer: NK007; M24 Dimensjon (LxBxH): 1420x700x900
Pset_Draughting - Red: 204; Green: 204; Blue: 204

# IfcBuildingElementProxy: *U22
ePset_ModelInfo - ModelName: m_f-elektro_trekkekummer.ifc; Timestamp: 2026-03-23T20:07:47
Prosessinfo - P03 Prosessnummer: 44.4613; P02 Element: D1 Elektro Vei; P04 Prosessnavn: Trekkekum type TK2 skrå 14 grader; P06 Enhet: stk; P05 Mengde: 1; P01 Sted: E1 Elektro
Merknader - M61 Tegningshenvisning: IN001 og IN053; M22 TFM-merking trekkekum: +S50VLS71D1=749.001 -NK005; M21 Kumnummer: NK005; M25 Skrå: 14gr; M24 Dimensjon (LxBxH): 1420x700x900; M20 Objektnavn: Trekkekum; M23 Kumtype: TK2
Tittelfelt - T10 Kontrollert av: renlie; T09 Utarbeidet av: andfyg; T05 Produsert for: DoV midt; T01 Vegstrekning: Ev006 S70D1 m9800 - S71D1 m340; T04 Bestiller: Thorstein Kjøs Johnsen; T02 Prosjektfase: Konkurransegrunnlag; T07 PROF-nummer: C16939-202; T06 Produsert av: Fagressurs DoV; T03 Dato: 24.03.26; T00 Prosjektnavn: E6 Lundamo bru
Pset_Draughting - Red: 204; Green: 204; Blue: 204

# IfcBuildingElementProxy: *U5 (2)
ePset_ModelInfo - ModelName: m_f-elektro_trekkekummer.ifc; Timestamp: 2026-03-23T20:07:47
Merknader - M24 Dimensjon (LxBxH): 1420x700x900; M25 Skrå: 0gr; M20 Objektnavn: Trekkekum; M23 Kumtype: TK2
Prosessinfo - P03 Prosessnummer: 44.4611; P02 Element: D1 Elektro Vei; P06 Enhet: stk; P05 Mengde: 1; P01 Sted: E1 Elektro; P04 Prosessnavn: Trekkekum type TK2 flat
Tittelfelt - T10 Kontrollert av: renlie; T09 Utarbeidet av: andfyg; T05 Produsert for: DoV midt; T01 Vegstrekning: Ev006 S70D1 m9800 - S71D1 m340; T04 Bestiller: Thorstein Kjøs Johnsen; T02 Prosjektfase: Konkurransegrunnlag; T07 PROF-nummer: C16939-202; T06 Produsert av: Fagressurs DoV; T03 Dato: 24.03.26; T00 Prosjektnavn: E6 Lundamo bru
Pset_Draughting - Red: 153; Green: 153; Blue: 153
Name | M61 Tegningshenvisning | M21 Kumnummer | M22 TFM-merking trekkekum
 | IN001 og IN053 | NK003 | +S50VLS70D1=749.001 -NK003
 | IN001, IN052 og IN053 | NK001 | +S50VLS70D1=749.001 -NK001

# IfcBuildingElementProxy: *U7 (2)
ePset_ModelInfo - ModelName: m_f-elektro_trekkekummer.ifc; Timestamp: 2026-03-23T20:07:47
Prosessinfo - P03 Prosessnummer: 44.4613; P02 Element: D1 Elektro Vei; P04 Prosessnavn: Trekkekum type TK2 skrå 14 grader; P06 Enhet: stk; P05 Mengde: 1; P01 Sted: E1 Elektro
Merknader - M61 Tegningshenvisning: IN001 og IN053; M25 Skrå: 14gr; M24 Dimensjon (LxBxH): 1420x700x900; M20 Objektnavn: Trekkekum; M23 Kumtype: TK2
Tittelfelt - T10 Kontrollert av: renlie; T09 Utarbeidet av: andfyg; T05 Produsert for: DoV midt; T01 Vegstrekning: Ev006 S70D1 m9800 - S71D1 m340; T04 Bestiller: Thorstein Kjøs Johnsen; T02 Prosjektfase: Konkurransegrunnlag; T07 PROF-nummer: C16939-202; T06 Produsert av: Fagressurs DoV; T03 Dato: 24.03.26; T00 Prosjektnavn: E6 Lundamo bru
Pset_Draughting - Red: 204; Green: 204; Blue: 204
Name | M21 Kumnummer | M22 TFM-merking trekkekum
 | NK002 | +S50VLS70D1=749.001 -NK002
 | NK006 | +S50VLS71D1=749.001 -NK006
