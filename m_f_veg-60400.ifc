Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: ViewDefinition [Alignment-basedView]
File name: C:\Users\klaids\AppData\Local\Temp\Trimble\ConnectFolder\Eksport til IFC-fil av m_f-veg-60400.ifc
Time: 2026-02-04T09:27:22
Author: Klaid Schjetne
Written by: Ifc Engine <1.0.1.1369>
Made in: Trimble Inc. - Novapoint - 27.0.1276.0
Authorization: Klaid Schjetne

# IfcProject, Default Project
Description: Description of the Project

# IfcSite, Default Site
RefLatitude: 10, 17, 26; RefLongitude: 63, 9, 11; RefElevation: 33.4244 m

# IfcActor (2)
Name
 | Pset_Address - Purpose: OFFICE; Country: Norway


# IfcAnnotation (28)
In: m_f_Veg-60400|ROADSEGMENT
Description: StakeOutStringTopLevel; PredefinedType: SURVEY
Name
4 x m_f_Veg-60400 / 6.11 / H. Jordskj. 11 / Line
4 x m_f_Veg-60400 / 4.01 / H. Grøft 01 / Line
2 x m_f_Veg-60400 / -7.11 / V. Fylling 11 / Line
m_f_Veg-60400 / -6.10 / V.Jordskj 10 / Line
4 x m_f_Veg-60400 / 6.10 / H.Jordskj 10 / Line
m_f_Veg-60400 / -4.01 / V. Grøft 01 / Line
4 x m_f_Veg-60400 / 7.11 / H. Fylling 11 / Line
m_f_Veg-60400 / -6.11 / V. Jordskj. 11 / Line
m_f_Veg-60400 / -2.19 / V. Kantsteinsflate / Line
m_f_Veg-60400 / -2.18 / V. Kantsteinsvis / Line
m_f_Veg-60400 / -2.01 / V. Skulder 01 / Line
m_f_Veg-60400 / -1.01 / V. Kjørefelt 01 / Line
m_f_Veg-60400 / 1.01 / H. Kjørefelt 01 / Line
m_f_Veg-60400 / 0 / Pavement / Centre Line
m_f_Veg-60400 / 2.01 / H. Skulder 01 / Line

# IfcCourse (7)
In: m_f_Veg-60400|ROADSEGMENT
PredefinedType: PAVEMENT; Material: Asphalt
Name
m_f_Veg-60400 / Bærelag 1
3 x m_f_Veg-60400 / Bindlag 1
3 x m_f_Veg-60400 / Slitelag

# IfcCourse: ROADSHOULDER_SURFACE (2)
In: m_f_Veg-60400|SHOULDER
PredefinedType: USERDEFINED
Name
m_f_Veg-60400 / -2.01 / V. Skulder 01
m_f_Veg-60400 / 2.01 / H. Skulder 01

# IfcCourse: TRAFFICLANE_SURFACE (2)
In: m_f_Veg-60400|CARRIAGEWAY
PredefinedType: USERDEFINED
Name
m_f_Veg-60400 / -1.01 / V. Kjørefelt 01
m_f_Veg-60400 / 1.01 / H. Kjørefelt 01

# IfcDistributionChamberElement (6)
In: m_f_Veg-60400|ROADSIDE
PredefinedType: TRENCH
Name
5 x m_f_Veg-60400 / 4.01 / H. Grøft 01
m_f_Veg-60400 / -4.01 / V. Grøft 01

# IfcEarthworksCut, m_f_Veg-60400 | Jord 1 | Solid
In: Default Site
PredefinedType: CUT

# IfcEarthworksCut: LOWESTCONSTRUCTIONWORKSURFACE (3)
In: Default Site
PredefinedType: USERDEFINED

# IfcEarthworksFill (39)
Name | In | PredefinedType
2 x m_f_Veg-60400 / Filterlag | m_f_Veg-60400/ROADSEGMENT | SUBGRADEBED | Material: Gravel
4 x m_f_Veg-60400 / Forsterkningslag 1 | m_f_Veg-60400/ROADSEGMENT | SUBGRADEBED | Material: Crushed stone
8 x m_f_Veg-60400 / SubgradeSurface Outside Pavement | m_f_Veg-60400/ROADSEGMENT | SUBGRADEBED
5 x m_f_Veg-60400 / 6.10 / H.Jordskj 10 | m_f_Veg-60400/ROADSIDE | SLOPEFILL
4 x m_f_Veg-60400 / 6.11 / H. Jordskj. 11 | m_f_Veg-60400/ROADSIDE | SLOPEFILL
5 x m_f_Veg-60400 / 7.11 / H. Fylling 11 | m_f_Veg-60400/ROADSIDE | SLOPEFILL
2 x m_f_Veg-60400 / SubgradeSurface Inside Pavement / InCutSoil | m_f_Veg-60400/ROADSEGMENT | SUBGRADEBED
3 x m_f_Veg-60400 / -7.11 / V. Fylling 11 | m_f_Veg-60400/ROADSIDE | SLOPEFILL
m_f_Veg-60400 / -6.11 / V. Jordskj. 11 | m_f_Veg-60400/ROADSIDE | SLOPEFILL
m_f_Veg-60400 / -6.10 / V.Jordskj 10 | m_f_Veg-60400/ROADSIDE | SLOPEFILL
2 x m_f_Veg-60400 / Fyllingslag / Solid | m_f_Veg-60400/ROADSEGMENT | EMBANKMENT | Material: Crushed stone
m_f_Veg-60400 / Filterlag | m_f_Veg-60400/ROADSEGMENT | SUBGRADEBED
m_f_Veg-60400/SUBGRADE | m_f_Veg-60400/ROADSEGMENT | SUBGRADE

# IfcEarthworksFill: LOWESTCONSTRUCTIONWORKSURFACE (5)
In: m_f_Veg-60400|ROADSEGMENT
PredefinedType: USERDEFINED

# IfcPavement, m_f_Veg-60400|RIGID
In: m_f_Veg-60400|ROADSEGMENT
PredefinedType: RIGID

# IfcRoad: Road, m_f_Veg-60400
PredefinedType: USERDEFINED

# IfcRoadPart (5)
Name | UsageType | PredefinedType
m_f_Veg-60400/ROADSEGMENT | LONGITUDINAL | ROADSEGMENT
m_f_Veg-60400/CARRIAGEWAY | LATERAL | CARRIAGEWAY
m_f_Veg-60400/SHOULDER | LATERAL | SHOULDER
m_f_Veg-60400/ROADSIDE | LATERAL | ROADSIDE
m_f_Veg-60400 | Description: Undefine of Road Part
