Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: C:\Users\janaal\OneDrive - Statens vegvesen\Grasshopper\Lundamo\m_f-geoteknikk_spunt.ifc
Time: 2026-04-30T15:09:30
Author: janaal
Organization: VEGVESEN
Written by: ggIFC v25.3.25.7 by Geometry Gym Pty Ltd built 2025-03-25T15:49:14
Made in: Geometry Gym - ggRhinoIFC - v25.3.25.7 - Rhino7 Grasshopper3d Plug-in by Geometry Gym Pty Ltd
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization

# IfcProject, E16 Lundamo bru
Description: Geofag; Phase: Prosjektering

# IfcSite, Fagmodell geoteknikk
RefElevation: 0 m

# IfcBuilding, Spunt
LongName: GH Building
Pset Prosjektinfo - Prosjektfase: Konkurransegrunnlag; Prosjektnummer: C16939

# IfcBuildingStorey (6)
In: Spunt
Elevation: 0 m
Name
2 x Spunt
2 x Forankring
2 x Pute

# IfcPile: FRICTION (551)
PredefinedType: FRICTION; Material: St\X2\00E5\X0\l
Name | In | Objektnavn | Prosesskode | MMI
146 x Spunt | Spunt | Spunt | 83.61 | 350 | Merknader - Totalt areal(m2): 1600
141 x Forankring | Forankring | Merknader - Antall: 23
6 x Pute | Pute | Pute | 83.66 | 350
258 x Spunt | Spunt | Spunt | 83.61 | 300 | Merknader - Akse: 1; Totalt areal (m2): 1600
