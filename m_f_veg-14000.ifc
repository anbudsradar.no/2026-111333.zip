Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: ViewDefinition [Alignment-basedView]
File name: C:\Users\klaids\AppData\Local\Temp\Trimble\ConnectFolder\m_f-veg-14000.ifc
Time: 2026-03-04T10:31:22
Author: Klaid Schjetne
Written by: Ifc Engine <1.0.1.1369>
Made in: Trimble Inc. - Novapoint - 28.0.290.0
Authorization: Klaid Schjetne

# IfcProject, Default Project
Description: Description of the Project

# IfcSite (2)
Name
Default Site | RefLatitude: 10, 17, 30; RefLongitude: 63, 9, 16; RefElevation: 32.2528 m
m_f_Veg-14000

# IfcActor (2)
Name
 | Pset_Address - Purpose: OFFICE; Country: Norway


# IfcAnnotation (45)
In: m_f_Veg-14000|ROADSEGMENT
PredefinedType: SURVEY
Name | Description
2 x m_f_Veg-14000 / 3.09 / H.Rekkverksrom / Line | StakeOutStringTopLevel
m_f_Veg-14000 / -7.11 / ConstructionPitEdgeSurface / Line 2 | StakeOutStringTopLevel
2 x m_f_Veg-14000 / -3.09 / V.Rekkverksrom / Line | StakeOutStringTopLevel
3 x m_f_Veg-14000 / 7.11 / H. Fylling 11 / Line | StakeOutStringTopLevel
2 x m_f_Veg-14000 / -7.11 / V. Fylling 11 / Line | StakeOutStringTopLevel
m_f_Veg-14000 / -1.02 / V.Breddeutvidelse / Line | StakeOutStringTopLevel
m_f_Veg-14000 / 1.02 / H.Breddeutvidelse / Line | StakeOutStringTopLevel
10 x m_f_Veg-14000 / 8.01 / ConstructionPitEdgeSurface / Line | StakeOutStringTopLevel
m_f_Veg-14000 / 2.02 / H."Avkj" / Line | StakeOutStringTopLevel
m_f_Veg-14000 / -7.11 / ConstructionPitEdgeSurface / Line 1 | StakeOutStringTopLevel
4 x m_f_Veg-14000 / -6.10 / V.Jordskj 10 / Line | StakeOutStringTopLevel
m_f_Veg-14000 / -1.01 / V. Kjørefelt 1 / Line | StakeOutStringTopLevel
m_f_Veg-14000 / -8.03 / ConstructionPitEdgeSurface / Line | StakeOutStringTopLevel
m_f_Veg-14000 / 0 / Pavement / Centre Line | StakeOutStringTopLevel
m_f_Veg-14000 / -2.01 / V. Skulder 1 / Line | StakeOutStringTopLevel
m_f_Veg-14000 / -4.01 / V. Grøft 1 / Line | StakeOutStringTopLevel
m_f_Veg-14000 / 1.01 / H. Kjørefelt 1 / Line | StakeOutStringTopLevel
m_f_Veg-14000 / -4.02 / V. Grøft 2 / Line | StakeOutStringTopLevel
m_f_Veg-14000 / -4.03 / V. Grøft 3 / Line | StakeOutStringTopLevel
m_f_Veg-14000 / 4.01 / H. Grøft 1 / Line | StakeOutStringTopLevel
m_f_Veg-14000 / 2.01 / H. Skulder 1 / Line | StakeOutStringTopLevel
m_f_Veg-14000 / 4.02 / H. Grøft 2 / Line | StakeOutStringTopLevel
m_f_Veg-14000 / Planum / Outer Boundary | StakeOutStringSubgradeImprovement
2 x m_f_Veg-14000 / 4.03 / H. Grøft 3 / Line | StakeOutStringTopLevel
m_f_Veg-14000 / -7.11 / ConstructionPitEdgeSurface / Line | StakeOutStringTopLevel
m_f_Veg-14000 / -8.02 / ConstructionPitEdgeSurface / Line | StakeOutStringTopLevel
m_f_Veg-14000 / -8.01 / ConstructionPitEdgeSurface / Line | StakeOutStringTopLevel

# IfcCourse (14)
In: m_f_Veg-14000|ROADSEGMENT
PredefinedType: PAVEMENT; Material: Asphalt
Name
m_f_Veg-14000 / Bindlag 2
4 x m_f_Veg-14000 / Bærelag 1
3 x m_f_Veg-14000 / Bærelag 2
3 x m_f_Veg-14000 / Bindlag 1
3 x m_f_Veg-14000 / Slitelag

# IfcCourse: ROADSHOULDER_SURFACE (7)
In: m_f_Veg-14000|SHOULDER
PredefinedType: USERDEFINED
Name
2 x m_f_Veg-14000 / -3.09 / V.Rekkverksrom
2 x m_f_Veg-14000 / 3.09 / H.Rekkverksrom
m_f_Veg-14000 / 2.02 / H."Avkj"
m_f_Veg-14000 / -2.01 / V. Skulder 1
m_f_Veg-14000 / 2.01 / H. Skulder 1

# IfcCourse: TRAFFICLANE_SURFACE (4)
In: m_f_Veg-14000|CARRIAGEWAY
PredefinedType: USERDEFINED
Name
m_f_Veg-14000 / -1.02 / V.Breddeutvidelse
m_f_Veg-14000 / 1.02 / H.Breddeutvidelse
m_f_Veg-14000 / -1.01 / V. Kjørefelt 1
m_f_Veg-14000 / 1.01 / H. Kjørefelt 1

# IfcDistributionChamberElement (8)
In: m_f_Veg-14000|ROADSIDE
PredefinedType: TRENCH
Name
3 x m_f_Veg-14000 / 4.03 / H. Grøft 3
m_f_Veg-14000 / -4.02 / V. Grøft 2
m_f_Veg-14000 / -4.03 / V. Grøft 3
m_f_Veg-14000 / 4.01 / H. Grøft 1
m_f_Veg-14000 / -4.01 / V. Grøft 1
m_f_Veg-14000 / 4.02 / H. Grøft 2

# IfcEarthworksCut (34)
In: m_f_Veg-14000
Name | PredefinedType
13 x m_f_Veg-14000 / 8.01 / ConstructionPitEdgeSurface | TOPSOILREMOVAL
2 x m_f_Veg-14000 / -8.02 / ConstructionPitEdgeSurface | TOPSOILREMOVAL
2 x m_f_Veg-14000 / -8.01 / ConstructionPitEdgeSurface | TOPSOILREMOVAL
m_f_Veg-14000 / -8.03 / ConstructionPitEdgeSurface | TOPSOILREMOVAL
3 x m_f_Veg-14000 / Utskifting 11 / Solid | TOPSOILREMOVAL
11 x m_f_Veg-14000 / Fjell 6 / Solid | CUT
2 x m_f_Veg-14000 / Matjord 16 / Solid | TOPSOILREMOVAL

# IfcEarthworksCut: LOWESTCONSTRUCTIONWORKSURFACE (26)
In: m_f_Veg-14000
PredefinedType: USERDEFINED
Name
17 x m_f_Veg-14000 / Constructionbed / InCutSoil
9 x m_f_Veg-14000 / Constructionbed / InCutRock

# IfcEarthworksFill (71)
Name | In | PredefinedType
5 x m_f_Veg-14000 / SubgradeSurface Without RoadBed | m_f_Veg-14000/ROADSEGMENT | SUBGRADEBED
26 x m_f_Veg-14000 / SubgradeSurface Inside Pavement / InCutSoil | m_f_Veg-14000/ROADSEGMENT | SUBGRADEBED
7 x m_f_Veg-14000 / SubgradeSurface Outside Pavement | m_f_Veg-14000/ROADSEGMENT | SUBGRADEBED
3 x m_f_Veg-14000 / SubgradeSurface Inside Pavement / InCutRock | m_f_Veg-14000/ROADSEGMENT | SUBGRADEBED
2 x m_f_Veg-14000 / -7.11 / V. Fylling 11 | m_f_Veg-14000/ROADSIDE | SLOPEFILL
3 x m_f_Veg-14000 / 7.11 / H. Fylling 11 | m_f_Veg-14000/ROADSIDE | SLOPEFILL
m_f_Veg-14000 / -6.10 / V.Jordskj 10 | m_f_Veg-14000/ROADSIDE | SLOPEFILL
2 x m_f_Veg-14000 / SubgradeSurface Inside Pavement / OnBridge | m_f_Veg-14000/ROADSEGMENT | SUBGRADEBED
2 x m_f_Veg-14000 / SubgradeSurface Inside Pavement / OnFill | m_f_Veg-14000/ROADSEGMENT | SUBGRADEBED
5 x m_f_Veg-14000 / Fyllingslag / Solid | m_f_Veg-14000/ROADSEGMENT | EMBANKMENT | Material: Crushed stone
6 x m_f_Veg-14000 / Indre fyllingsskråning / Solid | m_f_Veg-14000/ROADSIDE | SLOPEFILL | Material: 999
3 x m_f_Veg-14000 / Forsterkningslag 1 | m_f_Veg-14000/ROADSEGMENT | SUBGRADEBED | Material: Crushed stone
2 x m_f_Veg-14000 / Forsterkningslag 3 | m_f_Veg-14000/ROADSEGMENT | SUBGRADEBED | Material: Crushed stone
3 x m_f_Veg-14000 / Filterlag | m_f_Veg-14000/ROADSEGMENT | SUBGRADEBED | Material: Gravel
m_f_Veg-14000/SUBGRADE | m_f_Veg-14000/ROADSEGMENT | SUBGRADE

# IfcEarthworksFill: INNER_SLOPEFILL (6)
In: m_f_Veg-14000|WATER AND SEWER
PredefinedType: USERDEFINED

# IfcEarthworksFill: LOWESTCONSTRUCTIONWORKSURFACE (17)
In: m_f_Veg-14000|ROADSEGMENT
PredefinedType: USERDEFINED

# IfcElementAssembly: TRENCH
In: m_f_Veg-14000|WATER AND SEWER
PredefinedType: USERDEFINED

# IfcPavement, m_f_Veg-14000|RIGID
In: m_f_Veg-14000|ROADSEGMENT
PredefinedType: RIGID

# IfcReinforcedSoil (10)
PredefinedType: REPLACED; Material: Crushed stone
Name | In
m_f_Veg-14000 / Fyllingslag / Solid
9 x m_f_Veg-14000 / Fyllingslag / Solid | m_f_Veg-14000

# IfcRoad: Road, m_f_Veg-14000
PredefinedType: USERDEFINED

# IfcRoadPart (5)
Name | UsageType | PredefinedType
m_f_Veg-14000/ROADSEGMENT | LONGITUDINAL | ROADSEGMENT
m_f_Veg-14000/CARRIAGEWAY | LATERAL | CARRIAGEWAY
m_f_Veg-14000/SHOULDER | LATERAL | SHOULDER
m_f_Veg-14000/ROADSIDE | LATERAL | ROADSIDE
m_f_Veg-14000 | Description: Undefine of Road Part
