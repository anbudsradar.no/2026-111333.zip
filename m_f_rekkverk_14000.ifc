Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: ViewDefinition [Alignment-basedView]
File name: C:\Users\klaids\AppData\Local\Temp\Trimble\ConnectFolder\ m_f_rekkverk_14000.ifc
Time: 2026-02-13T12:21:28
Author: Klaid Schjetne
Organization: SVV
Written by: Ifc Engine <1.0.1.1369>
Made in: Trimble Inc. - Novapoint - 27.0.1276.0
Authorization: Klaid Schjetne

# IfcProject, Default Project
Description: Description of the Project

# IfcSite, Default Site
RefLatitude: 10, 17, 29; RefLongitude: 63, 9, 16; RefElevation: 32.0491 m

# IfcActor (2)
Name
 | Pset_Address - Purpose: OFFICE; Country: Norway


# IfcBuiltElement: PROXYOBJECT (263)
In: Import m_f_Rekkverk_14000_3D|WATER AND SEWER
Common - DWGFULLNAME: O:\PROF\Trondheim\C16939-010_E6_Ny-Lundamo-bru\Detaljprosjektering\05_2D\Tema\m_f-Veg-T_Rekkverk_14000_3D.dwg; DWGNAME: m_f-Veg-T_Rekkverk_14000_3D.dwg
Name | LocalId
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90B6
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90B4
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90B5
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90B8
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90B7
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90BA
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90B9
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90BB
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90BD
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90BC
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90BE
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90BF
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90C0
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90C1
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90C2
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90C3
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90C4
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90C5
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90C7
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90C6
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90C8
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90C9
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90CA
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90CB
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90CC
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90CE
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90CD
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90CF
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90D0
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90D2
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90D1
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90D3
VEG$14000_Rekkverk | m_f-Veg-T_Rekkverk_14000_3D_90D5
VEG$14000_Rekkverk | m_f-Veg-T_Rekkverk_14000_3D_90D4
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90D7
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90D6
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90D8
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90D9
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90A1
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90A0
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90A2
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90A3
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90A4
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90A5
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90A6
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90A7
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90A8
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90A9
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90AA
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90AC
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90AB
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90AD
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90AE
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90B0
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90AF
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90B1
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90B3
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90B2
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9021
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_901D
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8FCC
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9029
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9025
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9037
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9031
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_903D
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9045
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_904F
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_904E
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_904D
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9050
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9051
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9053
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9052
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9054
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9055
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9056
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9057
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9059
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9058
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_905B
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_905A
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_905C
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_905D
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_905E
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_905F
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9060
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9061
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9062
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9064
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9063
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9065
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9066
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9068
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9067
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_906B
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_906A
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9069
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_906C
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8FD9
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8FE5
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8FFF
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9003
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9007
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_900B
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9011
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9015
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9019
VEG$14000_Rekkverk | m_f-Veg-T_Rekkverk_14000_3D_8E61
VEG$14000_Rekkverk | m_f-Veg-T_Rekkverk_14000_3D_8E65
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8FB3
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8FC3
VEG$14000_Rekkverk | m_f-Veg-T_Rekkverk_14000_3D_8E6A
VEG$14000_Rekkverk | m_f-Veg-T_Rekkverk_14000_3D_8E69
VEG$14000_Rekkverk | m_f-Veg-T_Rekkverk_14000_3D_8E6B
VEG$14000_Rekkverk | m_f-Veg-T_Rekkverk_14000_3D_8E6C
VEG$14000_Rekkverk | m_f-Veg-T_Rekkverk_14000_3D_8E6E
VEG$14000_Rekkverk | m_f-Veg-T_Rekkverk_14000_3D_8E6F
VEG$14000_Rekkverk | m_f-Veg-T_Rekkverk_14000_3D_8E6D
VEG$14000_Rekkverk | m_f-Veg-T_Rekkverk_14000_3D_8E70
VEG$14000_Rekkverk | m_f-Veg-T_Rekkverk_14000_3D_8E71
VEG$14000_Rekkverk | m_f-Veg-T_Rekkverk_14000_3D_8E72
VEG$14000_Rekkverk | m_f-Veg-T_Rekkverk_14000_3D_8E73
VEG$14000_Rekkverk | m_f-Veg-T_Rekkverk_14000_3D_8E75
VEG$14000_Rekkverk | m_f-Veg-T_Rekkverk_14000_3D_8E74
VEG$14000_Rekkverk | m_f-Veg-T_Rekkverk_14000_3D_8E76
VEG$14000_Rekkverk | m_f-Veg-T_Rekkverk_14000_3D_8E78
VEG$14000_Rekkverk | m_f-Veg-T_Rekkverk_14000_3D_8E77
VEG$14000_Rekkverk | m_f-Veg-T_Rekkverk_14000_3D_8E7A
VEG$14000_Rekkverk | m_f-Veg-T_Rekkverk_14000_3D_8E79
VEG$14000_Rekkverk | m_f-Veg-T_Rekkverk_14000_3D_8E7B
VEG$14000_Rekkverk | m_f-Veg-T_Rekkverk_14000_3D_8E7D
VEG$14000_Rekkverk | m_f-Veg-T_Rekkverk_14000_3D_8E7C
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8E7F
VEG$14000_Rekkverk | m_f-Veg-T_Rekkverk_14000_3D_8E7E
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8E8F
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8E90
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8E96
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8E98
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8E97
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8E99
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8E9D
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8EA1
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8EB1
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8EA5
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8ECB
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8ECF
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8ED3
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8ED7
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8EDD
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8EE1
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8EE5
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8EF1
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8EE9
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8EED
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8EFD
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8EF5
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8F03
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8F09
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8F11
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8F29
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8F19
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8F30
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8F2A
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8F31
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8F32
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8F33
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8F3B
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8F37
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8F4B
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8F3F
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8F65
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8F6D
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8F69
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8F71
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8F77
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8F7F
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8F7B
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8F83
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8F87
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8F8B
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8F8F
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8F97
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8FA3
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8F9D
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8FAB
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9079
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_907A
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_907B
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_907D
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_907C
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_907E
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9080
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_907F
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9081
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9082
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9083
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9084
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9085
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9087
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9086
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9088
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9089
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_908A
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_908B
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_908C
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_908F
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_908D
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_908E
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9091
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9090
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9092
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9093
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9094
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9096
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9095
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9098
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9099
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9097
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_909B
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_909A
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_909C
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_909D
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_909F
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_909E
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_906D
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_906E
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_906F
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9071
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9070
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9073
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9072
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9074
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9075
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9076
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9078
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_9077
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90DC
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90DD
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90E0
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90DE
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90DF
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90E2
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90E1
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90E3
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90E4
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90E6
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90E5
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90E7
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90E8
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90E9
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90EA
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90EB
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90EC
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90ED
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8FCD
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8FD5
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8FD1
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90DB
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_90DA
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8FC4
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8FCA
f-energiabsorberende rekkverksende | m_f-Veg-T_Rekkverk_14000_3D_8FCB

# IfcElementAssembly: TRENCH
In: Import m_f_Rekkverk_14000_3D|WATER AND SEWER
PredefinedType: USERDEFINED
